* Functional test stimulus file for 10ns period

* SS process corner
.lib "/home/bala/OpenRAM/sky130A/libs.tech/ngspice/sky130.lib.spice" ss
.include "/tmp/openram_bala_7941_temp/sram.sp"

* Global Power Supplies
Vvdd vdd 0 1.6

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_128x32 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a1_0 a1_1 a1_2 a1_3 a1_4 a1_5 a1_6 CSB0 CSB1 WEB0 clk0 clk1 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 vdd gnd sram_128x32

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f
CD10 dout1_0  0 27.56f
CD11 dout1_1  0 27.56f
CD12 dout1_2  0 27.56f
CD13 dout1_3  0 27.56f
CD14 dout1_4  0 27.56f
CD15 dout1_5  0 27.56f
CD16 dout1_6  0 27.56f
CD17 dout1_7  0 27.56f
CD18 dout1_8  0 27.56f
CD19 dout1_9  0 27.56f
CD110 dout1_10  0 27.56f
CD111 dout1_11  0 27.56f
CD112 dout1_12  0 27.56f
CD113 dout1_13  0 27.56f
CD114 dout1_14  0 27.56f
CD115 dout1_15  0 27.56f
CD116 dout1_16  0 27.56f
CD117 dout1_17  0 27.56f
CD118 dout1_18  0 27.56f
CD119 dout1_19  0 27.56f
CD120 dout1_20  0 27.56f
CD121 dout1_21  0 27.56f
CD122 dout1_22  0 27.56f
CD123 dout1_23  0 27.56f
CD124 dout1_24  0 27.56f
CD125 dout1_25  0 27.56f
CD126 dout1_26  0 27.56f
CD127 dout1_27  0 27.56f
CD128 dout1_28  0 27.56f
CD129 dout1_29  0 27.56f
CD130 dout1_30  0 27.56f
CD131 dout1_31  0 27.56f
CD132 dout1_32  0 27.56f

* Important signals for debug
* bl:	xsram:xbank0:bl_0_1
* br:	xsram:xbank0:br_0_1
* s_en:	xsram:s_en
* q:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q
* qbar:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+10111011111000000000100001000110  to  address 1111110 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+00011011111100010000001110110010  to  address 0000001 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+01011011011000111010010111100110  to  address 0000001 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+01011011011000111010010111100110 from address 0000001 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 0+01011011011000111010010111100110 from address 0000001 (from port 1) during cycle 4 (40ns - 50ns)
*	Writing 0+10010010001010001011000000100000  to  address 0000001 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 1) during cycle 5 (50ns - 60ns)
*	Writing 0+01110001011111010111100100001001  to  address 0000000 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 1) during cycle 6 (60ns - 70ns)
*	Reading 0+10010010001010001011000000100000 from address 0000001 (from port 0) during cycle 7 (70ns - 80ns)
*	Reading 0+10010010001010001011000000100000 from address 0000001 (from port 1) during cycle 7 (70ns - 80ns)
*	Reading 0+10010010001010001011000000100000 from address 0000001 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 0+10010010001010001011000000100000 from address 0000001 (from port 1) during cycle 8 (80ns - 90ns)
*	Writing 0+11110111100011011011010101111110  to  address 0000001 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 1) during cycle 10 (100ns - 110ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 12 (120ns - 130ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 1) during cycle 12 (120ns - 130ns)
*	Reading 0+11110111100011011011010101111110 from address 0000001 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 0+10111011111000000000100001000110 from address 1111110 (from port 1) during cycle 15 (150ns - 160ns)
*	Reading 0+11110111100011011011010101111110 from address 0000001 (from port 1) during cycle 16 (160ns - 170ns)
*	Writing 0+10111010100001001010101000011101  to  address 1111110 (from port 0) during cycle 17 (170ns - 180ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 0+11110111100011011011010101111110 from address 0000001 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 0+11110111100011011011010101111110 from address 0000001 (from port 1) during cycle 20 (200ns - 210ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 21 (210ns - 220ns)
*	Writing 0+11011011101001000101000110111111  to  address 0000001 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 1) during cycle 22 (220ns - 230ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 0) during cycle 23 (230ns - 240ns)
*	Reading 0+10111010100001001010101000011101 from address 1111110 (from port 1) during cycle 25 (250ns - 260ns)
*	Reading 0+11011011101001000101000110111111 from address 0000001 (from port 0) during cycle 27 (270ns - 280ns)
*	Reading 0+01110001011111010111100100001001 from address 0000000 (from port 1) during cycle 27 (270ns - 280ns)
*	Writing 0+11001110011000000111110010010000  to  address 1111101 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 0+11011011101001000101000110111111 from address 0000001 (from port 1) during cycle 28 (280ns - 290ns)
*	Writing 0+01100011010011101111001101001000  to  address 0000000 (from port 0) during cycle 29 (290ns - 300ns)
*	Writing 0+01010101110100100011100000100000  to  address 0000001 (from port 0) during cycle 30 (300ns - 310ns)
*	Reading 0+11001110011000000111110010010000 from address 1111101 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 0+10111010100001001010101000011101 from address 1111110 (from port 0) during cycle 33 (330ns - 340ns)
*	Writing 0+11000110100101110101000101101010  to  address 1111101 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 0+01100011010011101111001101001000 from address 0000000 (from port 1) during cycle 35 (350ns - 360ns)
*	Writing 0+10111110100100011011110110111001  to  address 1111101 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 0+01010101110100100011100000100000 from address 0000001 (from port 1) during cycle 37 (370ns - 380ns)
*	Writing 0+11000101100010010000100111100110  to  address 0000001 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 0+11000101100010010000100111100110 from address 0000001 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing 0+00010100100011110001001010100100  to  address 0000001 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 0+10111010100001001010101000011101 from address 1111110 (from port 1) during cycle 40 (400ns - 410ns)
*	Reading 0+10111110100100011011110110111001 from address 1111101 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 0+01100011010011101111001101001000 from address 0000000 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 0+10111110100100011011110110111001 from address 1111101 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 1) during cycle 43 (430ns - 440ns)
*	Reading 0+01100011010011101111001101001000 from address 0000000 (from port 0) during cycle 44 (440ns - 450ns)
*	Writing 0+11010111010001110000100110011111  to  address 1111110 (from port 0) during cycle 45 (450ns - 460ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing 0+01111100010001111010010100001101  to  address 0000000 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 0+10111110100100011011110110111001 from address 1111101 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 0+01111100010001111010010100001101 from address 0000000 (from port 1) during cycle 50 (500ns - 510ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 1) during cycle 52 (520ns - 530ns)
*	Writing 0+00101011101100001001111111000001  to  address 1111101 (from port 0) during cycle 53 (530ns - 540ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 0+01111100010001111010010100001101 from address 0000000 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 58 (580ns - 590ns)
*	Reading 0+01111100010001111010010100001101 from address 0000000 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 59 (590ns - 600ns)
*	Reading 0+01111100010001111010010100001101 from address 0000000 (from port 0) during cycle 60 (600ns - 610ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 61 (610ns - 620ns)
*	Reading 0+00010100100011110001001010100100 from address 0000001 (from port 1) during cycle 61 (610ns - 620ns)
*	Writing 0+00100111111011000110111010001110  to  address 0000000 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 63 (630ns - 640ns)
*	Writing 0+00100111010010100101111001111011  to  address 0000001 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 65 (650ns - 660ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 0) during cycle 66 (660ns - 670ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 66 (660ns - 670ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 67 (670ns - 680ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 1) during cycle 70 (700ns - 710ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 1) during cycle 72 (720ns - 730ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 0) during cycle 73 (730ns - 740ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 73 (730ns - 740ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 1) during cycle 74 (740ns - 750ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 76 (760ns - 770ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 0+00101011101100001001111111000001 from address 1111101 (from port 1) during cycle 78 (780ns - 790ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 0+11111101100011111000001001010111  to  address 1111101 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+00100111111011000110111010001110 from address 0000000 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 82 (820ns - 830ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 1) during cycle 85 (850ns - 860ns)
*	Writing 0+01010010111111011010110010000111  to  address 1111101 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 1) during cycle 86 (860ns - 870ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 87 (870ns - 880ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 0+01010010111111011010110010000111 from address 1111101 (from port 1) during cycle 88 (880ns - 890ns)
*	Reading 0+01010010111111011010110010000111 from address 1111101 (from port 0) during cycle 89 (890ns - 900ns)
*	Writing 0+01010010111110000010100001101101  to  address 0000000 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 0+00100111010010100101111001111011 from address 0000001 (from port 1) during cycle 90 (900ns - 910ns)
*	Writing 0+01011000110001001101111010110010  to  address 0000001 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 91 (910ns - 920ns)
*	Reading 0+01010010111111011010110010000111 from address 1111101 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+01011000110001001101111010110010 from address 0000001 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+01011000110001001101111010110010 from address 0000001 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 0+01010010111111011010110010000111 from address 1111101 (from port 1) during cycle 94 (940ns - 950ns)
*	Reading 0+01010010111110000010100001101101 from address 0000000 (from port 0) during cycle 95 (950ns - 960ns)
*	Writing 0+00100011001101100111111111100111  to  address 0000001 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 0+01010010111110000010100001101101 from address 0000000 (from port 1) during cycle 96 (960ns - 970ns)
*	Reading 0+01010010111110000010100001101101 from address 0000000 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 1) during cycle 97 (970ns - 980ns)
*	Reading 0+01010010111111011010110010000111 from address 1111101 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 99 (990ns - 1000ns)
*	Writing 0+00101111001100111010100010101001  to  address 1111101 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+01010010111110000010100001101101 from address 0000000 (from port 1) during cycle 102 (1020ns - 1030ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 0+01010010111110000010100001101101 from address 0000000 (from port 1) during cycle 103 (1030ns - 1040ns)
*	Writing 0+11000110100111010011000111001110  to  address 0000000 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Reading 0+11000110100111010011000111001110 from address 0000000 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 107 (1070ns - 1080ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 1) during cycle 108 (1080ns - 1090ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 0+11000110100111010011000111001110 from address 0000000 (from port 1) during cycle 109 (1090ns - 1100ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 1) during cycle 110 (1100ns - 1110ns)
*	Reading 0+00101111001100111010100010101001 from address 1111101 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 1) during cycle 112 (1120ns - 1130ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 113 (1130ns - 1140ns)
*	Reading 0+11000110100111010011000111001110 from address 0000000 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 1) during cycle 114 (1140ns - 1150ns)
*	Writing 0+11011110001100101010101001000010  to  address 1111101 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Writing 0+00000111100011000011101101000011  to  address 0000000 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 0+11011110001100101010101001000010 from address 1111101 (from port 1) during cycle 117 (1170ns - 1180ns)
*	Reading 0+11011110001100101010101001000010 from address 1111101 (from port 1) during cycle 118 (1180ns - 1190ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 1) during cycle 119 (1190ns - 1200ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 120 (1200ns - 1210ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 121 (1210ns - 1220ns)
*	Reading 0+00100011001101100111111111100111 from address 0000001 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 0+11010111010001110000100110011111 from address 1111110 (from port 1) during cycle 123 (1230ns - 1240ns)
*	Reading 0+11011110001100101010101001000010 from address 1111101 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Writing 0+00010001110111111111011000101101  to  address 0000001 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 0+11011110001100101010101001000010 from address 1111101 (from port 1) during cycle 126 (1260ns - 1270ns)
*	Reading 0+11011110001100101010101001000010 from address 1111101 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Writing 0+11010100001001101110100100011111  to  address 1111110 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing 0+10110110011011011010110001101111  to  address 1111101 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 1) during cycle 131 (1310ns - 1320ns)
*	Reading 0+10110110011011011010110001101111 from address 1111101 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 1) during cycle 132 (1320ns - 1330ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 0+11010100001001101110100100011111 from address 1111110 (from port 1) during cycle 134 (1340ns - 1350ns)
*	Writing 0+01000011000111100111001010000111  to  address 1111110 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 0+01000011000111100111001010000111 from address 1111110 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Reading 0+00000111100011000011101101000011 from address 0000000 (from port 1) during cycle 139 (1390ns - 1400ns)
*	Writing 0+11110010000110010101101110100011  to  address 0000000 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Reading 0+10110110011011011010110001101111 from address 1111101 (from port 1) during cycle 140 (1400ns - 1410ns)
*	Reading 0+01000011000111100111001010000111 from address 1111110 (from port 1) during cycle 142 (1420ns - 1430ns)
*	Writing 0+00001011010001010110101000110010  to  address 0000001 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 0+11110010000110010101101110100011 from address 0000000 (from port 1) during cycle 143 (1430ns - 1440ns)
*	Reading 0+00001011010001010110101000110010 from address 0000001 (from port 1) during cycle 144 (1440ns - 1450ns)
*	Writing 0+00101010101001011111000001101101  to  address 0000001 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 0+00101010101001011111000001101101 from address 0000001 (from port 1) during cycle 146 (1460ns - 1470ns)
*	Reading 0+00101010101001011111000001101101 from address 0000001 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 0+11110010000110010101101110100011 from address 0000000 (from port 1) during cycle 148 (1480ns - 1490ns)
*	Writing 0+00110000111111011100101110101011  to  address 1111101 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Writing 0+11001010110001111011001000001000  to  address 1111101 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 0+01000011000111100111001010000111 from address 1111110 (from port 1) during cycle 150 (1500ns - 1510ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 0+01000011000111100111001010000111 from address 1111110 (from port 1) during cycle 151 (1510ns - 1520ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 152 (1520ns - 1530ns)
*	Reading 0+00101010101001011111000001101101 from address 0000001 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 154 (1540ns - 1550ns)
*	Writing 0+01100001001000001111001000100101  to  address 0000000 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing 0+11010110000010101011110010010011  to  address 1111110 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 0+11010110000010101011110010010011 from address 1111110 (from port 1) during cycle 157 (1570ns - 1580ns)
*	Writing 0+10011101101011110011000010000110  to  address 0000001 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 158 (1580ns - 1590ns)
*	Reading 0+01100001001000001111001000100101 from address 0000000 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+11010110000010101011110010010011 from address 1111110 (from port 1) during cycle 159 (1590ns - 1600ns)
*	Reading 0+10011101101011110011000010000110 from address 0000001 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 0+10011101101011110011000010000110 from address 0000001 (from port 1) during cycle 160 (1600ns - 1610ns)
*	Writing 0+00110011001100110101000100001110  to  address 1111110 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 0+01100001001000001111001000100101 from address 0000000 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Reading 0+01100001001000001111001000100101 from address 0000000 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 0+00110011001100110101000100001110 from address 1111110 (from port 1) during cycle 163 (1630ns - 1640ns)
*	Reading 0+01100001001000001111001000100101 from address 0000000 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 0+01100001001000001111001000100101 from address 0000000 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Writing 0+00011011001101111100100111101110  to  address 0000000 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 0+00110011001100110101000100001110 from address 1111110 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+10011101101011110011000010000110 from address 0000001 (from port 1) during cycle 168 (1680ns - 1690ns)
*	Reading 0+10011101101011110011000010000110 from address 0000001 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Writing 0+11001010010000000110010010010101  to  address 0000001 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Writing 0+00101101101101000111100001010110  to  address 0000000 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 171 (1710ns - 1720ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 0+00110011001100110101000100001110 from address 1111110 (from port 1) during cycle 172 (1720ns - 1730ns)
*	Reading 0+00101101101101000111100001010110 from address 0000000 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 173 (1730ns - 1740ns)
*	Reading 0+11001010010000000110010010010101 from address 0000001 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Reading 0+00101101101101000111100001010110 from address 0000000 (from port 1) during cycle 176 (1760ns - 1770ns)
*	Reading 0+11001010010000000110010010010101 from address 0000001 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 0+00110011001100110101000100001110 from address 1111110 (from port 1) during cycle 178 (1780ns - 1790ns)
*	Writing 0+11000110111111000011010010001011  to  address 1111110 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 0+00101000100000010011010100001001  to  address 0000001 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 180 (1800ns - 1810ns)
*	Reading 0+00101000100000010011010100001001 from address 0000001 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 0+11001010110001111011001000001000 from address 1111101 (from port 1) during cycle 181 (1810ns - 1820ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing 0+11011001001001111100100111101000  to  address 1111101 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 0+00101000100000010011010100001001 from address 0000001 (from port 1) during cycle 184 (1840ns - 1850ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 0+00101000100000010011010100001001 from address 0000001 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+00101000100000010011010100001001 from address 0000001 (from port 1) during cycle 187 (1870ns - 1880ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 1) during cycle 189 (1890ns - 1900ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 1) during cycle 192 (1920ns - 1930ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 1) during cycle 193 (1930ns - 1940ns)
*	Writing 0+11000100010110111111111100001100  to  address 0000000 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 0+11000110111111000011010010001011 from address 1111110 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 0+11000100010110111111111100001100 from address 0000000 (from port 1) during cycle 195 (1950ns - 1960ns)
*	Reading 0+11000100010110111111111100001100 from address 0000000 (from port 1) during cycle 196 (1960ns - 1970ns)
*	Reading 0+00101000100000010011010100001001 from address 0000001 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Reading 0+11000100010110111111111100001100 from address 0000000 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 0+10011010000011010100000100001010  to  address 0000001 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 0+10011010000011010100000100001010 from address 0000001 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 1) during cycle 200 (2000ns - 2010ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Reading 0+11000100010110111111111100001100 from address 0000000 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Reading 0+10011010000011010100000100001010 from address 0000001 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Reading 0+11011001001001111100100111101000 from address 1111101 (from port 1) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 1.6v 69.495n 1.6v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 1.6v 229.495n 1.6v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 0), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 1.6v 49.495n 1.6v 49.505n 1.6v 59.495n 1.6v 59.505n 0.0v 69.495n 0.0v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.6v 149.495n 1.6v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.6v 199.495n 1.6v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.6v 229.495n 1.6v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.6v 279.495n 1.6v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 0.0v 889.495n 0.0v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 0.0v 959.495n 0.0v 959.505n 1.6v 969.495n 1.6v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.6v 1439.495n 1.6v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.6v 889.495n 1.6v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 0.0v 559.495n 0.0v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 0.0v 559.495n 0.0v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 0.0v 559.495n 0.0v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 0.0v 559.495n 0.0v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.6v 19.495n 1.6v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 1.6v 359.495n 1.6v 359.505n 1.6v 369.495n 1.6v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 0.0v 449.495n 0.0v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 0.0v 559.495n 0.0v 559.505n 1.6v 569.495n 1.6v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 0.0v 799.495n 0.0v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_0  a1_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 1.6v 99.495n 1.6v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.6v 169.495n 1.6v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.6v 289.495n 1.6v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.6v 379.495n 1.6v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.6v 529.495n 1.6v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.6v 619.495n 1.6v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.6v 859.495n 1.6v 859.505n 1.6v 869.495n 1.6v 869.505n 0.0v 879.495n 0.0v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 1.6v 909.495n 1.6v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_2  a1_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_4  a1_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_5  a1_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_6  a1_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.6v 59.495n 1.6v 59.505n 1.6v 69.495n 1.6v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.6v 409.495n 1.6v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.6v 739.495n 1.6v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 1.6v 919.495n 1.6v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 1.6v 1269.495n 1.6v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.6v 1409.495n 1.6v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.6v 1509.495n 1.6v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 1.6v 1589.495n 1.6v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.6v 1719.495n 1.6v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 1.6v 1809.495n 1.6v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 1), (730, 0), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.6v 9.495n 1.6v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 1.6v 139.495n 1.6v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.6v 319.495n 1.6v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.6v 469.495n 1.6v 469.505n 0.0v 479.495n 0.0v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.6v 589.495n 1.6v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.6v 689.495n 1.6v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.6v 729.495n 1.6v 729.505n 0.0v 739.495n 0.0v 739.505n 1.6v 749.495n 1.6v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.6v 839.495n 1.6v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.6v 989.495n 1.6v 989.505n 0.0v 999.495n 0.0v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )
* (time, data): [(0, 1), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 0), (210, 1), (220, 0), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 1)]
VCSB1 CSB1 0 PWL (0n 1.6v 9.495n 1.6v 9.505n 1.6v 19.495n 1.6v 19.505n 1.6v 29.495n 1.6v 29.505n 1.6v 39.495n 1.6v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.6v 99.495n 1.6v 99.505n 0.0v 109.495n 0.0v 109.505n 1.6v 119.495n 1.6v 119.505n 0.0v 129.495n 0.0v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.6v 179.495n 1.6v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 0.0v 209.495n 0.0v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 0.0v 259.495n 0.0v 259.505n 1.6v 269.495n 1.6v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.6v 299.495n 1.6v 299.505n 1.6v 309.495n 1.6v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 1.6v 369.495n 1.6v 369.505n 0.0v 379.495n 0.0v 379.505n 1.6v 389.495n 1.6v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 0.0v 439.495n 0.0v 439.505n 1.6v 449.495n 1.6v 449.505n 1.6v 459.495n 1.6v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 1.6v 499.495n 1.6v 499.505n 0.0v 509.495n 0.0v 509.505n 1.6v 519.495n 1.6v 519.505n 0.0v 529.495n 0.0v 529.505n 1.6v 539.495n 1.6v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.6v 609.495n 1.6v 609.505n 0.0v 619.495n 0.0v 619.505n 1.6v 629.495n 1.6v 629.505n 1.6v 639.495n 1.6v 639.505n 1.6v 649.495n 1.6v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 0.0v 709.495n 0.0v 709.505n 1.6v 719.495n 1.6v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.6v 759.495n 1.6v 759.505n 0.0v 769.495n 0.0v 769.505n 1.6v 779.495n 1.6v 779.505n 0.0v 789.495n 0.0v 789.505n 1.6v 799.495n 1.6v 799.505n 1.6v 809.495n 1.6v 809.505n 1.6v 819.495n 1.6v 819.505n 0.0v 829.495n 0.0v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 0.0v 949.495n 0.0v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.6v 989.495n 1.6v 989.505n 0.0v 999.495n 0.0v 999.505n 1.6v 1009.495n 1.6v 1009.505n 1.6v 1019.495n 1.6v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.6v 1049.495n 1.6v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.6v 1159.495n 1.6v 1159.505n 1.6v 1169.495n 1.6v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 1.6v 1289.495n 1.6v 1289.505n 1.6v 1299.495n 1.6v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.6v 1359.495n 1.6v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.6v 1459.495n 1.6v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.6v 1499.495n 1.6v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.6v 1559.495n 1.6v 1559.505n 1.6v 1569.495n 1.6v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.6v 1619.495n 1.6v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 1.6v 1669.495n 1.6v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 1.6v 1709.495n 1.6v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.6v 1799.495n 1.6v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 1.6v 1839.495n 1.6v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.6v 1949.495n 1.6v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 1.6v 1999.495n 1.6v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.6v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.6v 9.495n 1.6v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.6v 49.495n 1.6v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.6v 79.495n 1.6v 79.505n 1.6v 89.495n 1.6v 89.505n 0.0v 99.495n 0.0v 99.505n 1.6v 109.495n 1.6v 109.505n 1.6v 119.495n 1.6v 119.505n 1.6v 129.495n 1.6v 129.505n 1.6v 139.495n 1.6v 139.505n 1.6v 149.495n 1.6v 149.505n 1.6v 159.495n 1.6v 159.505n 1.6v 169.495n 1.6v 169.505n 0.0v 179.495n 0.0v 179.505n 1.6v 189.495n 1.6v 189.505n 1.6v 199.495n 1.6v 199.505n 1.6v 209.495n 1.6v 209.505n 1.6v 219.495n 1.6v 219.505n 0.0v 229.495n 0.0v 229.505n 1.6v 239.495n 1.6v 239.505n 1.6v 249.495n 1.6v 249.505n 1.6v 259.495n 1.6v 259.505n 1.6v 269.495n 1.6v 269.505n 1.6v 279.495n 1.6v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.6v 319.495n 1.6v 319.505n 1.6v 329.495n 1.6v 329.505n 1.6v 339.495n 1.6v 339.505n 1.6v 349.495n 1.6v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.6v 379.495n 1.6v 379.505n 0.0v 389.495n 0.0v 389.505n 1.6v 399.495n 1.6v 399.505n 0.0v 409.495n 0.0v 409.505n 1.6v 419.495n 1.6v 419.505n 1.6v 429.495n 1.6v 429.505n 1.6v 439.495n 1.6v 439.505n 1.6v 449.495n 1.6v 449.505n 0.0v 459.495n 0.0v 459.505n 1.6v 469.495n 1.6v 469.505n 1.6v 479.495n 1.6v 479.505n 1.6v 489.495n 1.6v 489.505n 0.0v 499.495n 0.0v 499.505n 1.6v 509.495n 1.6v 509.505n 1.6v 519.495n 1.6v 519.505n 1.6v 529.495n 1.6v 529.505n 0.0v 539.495n 0.0v 539.505n 1.6v 549.495n 1.6v 549.505n 1.6v 559.495n 1.6v 559.505n 1.6v 569.495n 1.6v 569.505n 1.6v 579.495n 1.6v 579.505n 1.6v 589.495n 1.6v 589.505n 1.6v 599.495n 1.6v 599.505n 1.6v 609.495n 1.6v 609.505n 1.6v 619.495n 1.6v 619.505n 0.0v 629.495n 0.0v 629.505n 1.6v 639.495n 1.6v 639.505n 0.0v 649.495n 0.0v 649.505n 1.6v 659.495n 1.6v 659.505n 1.6v 669.495n 1.6v 669.505n 1.6v 679.495n 1.6v 679.505n 1.6v 689.495n 1.6v 689.505n 1.6v 699.495n 1.6v 699.505n 1.6v 709.495n 1.6v 709.505n 1.6v 719.495n 1.6v 719.505n 1.6v 729.495n 1.6v 729.505n 1.6v 739.495n 1.6v 739.505n 1.6v 749.495n 1.6v 749.505n 1.6v 759.495n 1.6v 759.505n 1.6v 769.495n 1.6v 769.505n 1.6v 779.495n 1.6v 779.505n 1.6v 789.495n 1.6v 789.505n 1.6v 799.495n 1.6v 799.505n 0.0v 809.495n 0.0v 809.505n 1.6v 819.495n 1.6v 819.505n 1.6v 829.495n 1.6v 829.505n 1.6v 839.495n 1.6v 839.505n 1.6v 849.495n 1.6v 849.505n 1.6v 859.495n 1.6v 859.505n 0.0v 869.495n 0.0v 869.505n 1.6v 879.495n 1.6v 879.505n 1.6v 889.495n 1.6v 889.505n 1.6v 899.495n 1.6v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.6v 929.495n 1.6v 929.505n 1.6v 939.495n 1.6v 939.505n 1.6v 949.495n 1.6v 949.505n 1.6v 959.495n 1.6v 959.505n 0.0v 969.495n 0.0v 969.505n 1.6v 979.495n 1.6v 979.505n 1.6v 989.495n 1.6v 989.505n 1.6v 999.495n 1.6v 999.505n 1.6v 1009.495n 1.6v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.6v 1029.495n 1.6v 1029.505n 1.6v 1039.495n 1.6v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.6v 1059.495n 1.6v 1059.505n 1.6v 1069.495n 1.6v 1069.505n 1.6v 1079.495n 1.6v 1079.505n 1.6v 1089.495n 1.6v 1089.505n 1.6v 1099.495n 1.6v 1099.505n 1.6v 1109.495n 1.6v 1109.505n 1.6v 1119.495n 1.6v 1119.505n 1.6v 1129.495n 1.6v 1129.505n 1.6v 1139.495n 1.6v 1139.505n 1.6v 1149.495n 1.6v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.6v 1179.495n 1.6v 1179.505n 1.6v 1189.495n 1.6v 1189.505n 1.6v 1199.495n 1.6v 1199.505n 1.6v 1209.495n 1.6v 1209.505n 1.6v 1219.495n 1.6v 1219.505n 1.6v 1229.495n 1.6v 1229.505n 1.6v 1239.495n 1.6v 1239.505n 1.6v 1249.495n 1.6v 1249.505n 1.6v 1259.495n 1.6v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.6v 1279.495n 1.6v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.6v 1309.495n 1.6v 1309.505n 1.6v 1319.495n 1.6v 1319.505n 1.6v 1329.495n 1.6v 1329.505n 1.6v 1339.495n 1.6v 1339.505n 1.6v 1349.495n 1.6v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.6v 1369.495n 1.6v 1369.505n 1.6v 1379.495n 1.6v 1379.505n 1.6v 1389.495n 1.6v 1389.505n 1.6v 1399.495n 1.6v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.6v 1419.495n 1.6v 1419.505n 1.6v 1429.495n 1.6v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.6v 1449.495n 1.6v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.6v 1469.495n 1.6v 1469.505n 1.6v 1479.495n 1.6v 1479.505n 1.6v 1489.495n 1.6v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.6v 1519.495n 1.6v 1519.505n 1.6v 1529.495n 1.6v 1529.505n 1.6v 1539.495n 1.6v 1539.505n 1.6v 1549.495n 1.6v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.6v 1579.495n 1.6v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.6v 1599.495n 1.6v 1599.505n 1.6v 1609.495n 1.6v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.6v 1629.495n 1.6v 1629.505n 1.6v 1639.495n 1.6v 1639.505n 1.6v 1649.495n 1.6v 1649.505n 1.6v 1659.495n 1.6v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.6v 1679.495n 1.6v 1679.505n 1.6v 1689.495n 1.6v 1689.505n 1.6v 1699.495n 1.6v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.6v 1729.495n 1.6v 1729.505n 1.6v 1739.495n 1.6v 1739.505n 1.6v 1749.495n 1.6v 1749.505n 1.6v 1759.495n 1.6v 1759.505n 1.6v 1769.495n 1.6v 1769.505n 1.6v 1779.495n 1.6v 1779.505n 1.6v 1789.495n 1.6v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.6v 1819.495n 1.6v 1819.505n 1.6v 1829.495n 1.6v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.6v 1849.495n 1.6v 1849.505n 1.6v 1859.495n 1.6v 1859.505n 1.6v 1869.495n 1.6v 1869.505n 1.6v 1879.495n 1.6v 1879.505n 1.6v 1889.495n 1.6v 1889.505n 1.6v 1899.495n 1.6v 1899.505n 1.6v 1909.495n 1.6v 1909.505n 1.6v 1919.495n 1.6v 1919.505n 1.6v 1929.495n 1.6v 1929.505n 1.6v 1939.495n 1.6v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.6v 1959.495n 1.6v 1959.505n 1.6v 1969.495n 1.6v 1969.505n 1.6v 1979.495n 1.6v 1979.505n 1.6v 1989.495n 1.6v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.6v 2009.495n 1.6v 2009.505n 1.6v 2019.495n 1.6v 2019.505n 1.6v 2029.495n 1.6v 2029.505n 1.6v 2039.495n 1.6v 2039.505n 1.6v 2049.495n 1.6v 2049.505n 1.6v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.6 9.995n 0.01n 0.01n 4.99n 10n)
* PULSE: period=10
Vclk1 clk1 0 PULSE (0 1.6 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 vdout0_0ck4 = 0 time = 50
* CHECK dout0_1 vdout0_1ck4 = 1.6 time = 50
* CHECK dout0_2 vdout0_2ck4 = 1.6 time = 50
* CHECK dout0_3 vdout0_3ck4 = 0 time = 50
* CHECK dout0_4 vdout0_4ck4 = 0 time = 50
* CHECK dout0_5 vdout0_5ck4 = 1.6 time = 50
* CHECK dout0_6 vdout0_6ck4 = 1.6 time = 50
* CHECK dout0_7 vdout0_7ck4 = 1.6 time = 50
* CHECK dout0_8 vdout0_8ck4 = 1.6 time = 50
* CHECK dout0_9 vdout0_9ck4 = 0 time = 50
* CHECK dout0_10 vdout0_10ck4 = 1.6 time = 50
* CHECK dout0_11 vdout0_11ck4 = 0 time = 50
* CHECK dout0_12 vdout0_12ck4 = 0 time = 50
* CHECK dout0_13 vdout0_13ck4 = 1.6 time = 50
* CHECK dout0_14 vdout0_14ck4 = 0 time = 50
* CHECK dout0_15 vdout0_15ck4 = 1.6 time = 50
* CHECK dout0_16 vdout0_16ck4 = 1.6 time = 50
* CHECK dout0_17 vdout0_17ck4 = 1.6 time = 50
* CHECK dout0_18 vdout0_18ck4 = 0 time = 50
* CHECK dout0_19 vdout0_19ck4 = 0 time = 50
* CHECK dout0_20 vdout0_20ck4 = 0 time = 50
* CHECK dout0_21 vdout0_21ck4 = 1.6 time = 50
* CHECK dout0_22 vdout0_22ck4 = 1.6 time = 50
* CHECK dout0_23 vdout0_23ck4 = 0 time = 50
* CHECK dout0_24 vdout0_24ck4 = 1.6 time = 50
* CHECK dout0_25 vdout0_25ck4 = 1.6 time = 50
* CHECK dout0_26 vdout0_26ck4 = 0 time = 50
* CHECK dout0_27 vdout0_27ck4 = 1.6 time = 50
* CHECK dout0_28 vdout0_28ck4 = 1.6 time = 50
* CHECK dout0_29 vdout0_29ck4 = 0 time = 50
* CHECK dout0_30 vdout0_30ck4 = 1.6 time = 50
* CHECK dout0_31 vdout0_31ck4 = 0 time = 50
* CHECK dout0_32 vdout0_32ck4 = 0 time = 50
* CHECK dout1_0 vdout1_0ck4 = 0 time = 50
* CHECK dout1_1 vdout1_1ck4 = 1.6 time = 50
* CHECK dout1_2 vdout1_2ck4 = 1.6 time = 50
* CHECK dout1_3 vdout1_3ck4 = 0 time = 50
* CHECK dout1_4 vdout1_4ck4 = 0 time = 50
* CHECK dout1_5 vdout1_5ck4 = 1.6 time = 50
* CHECK dout1_6 vdout1_6ck4 = 1.6 time = 50
* CHECK dout1_7 vdout1_7ck4 = 1.6 time = 50
* CHECK dout1_8 vdout1_8ck4 = 1.6 time = 50
* CHECK dout1_9 vdout1_9ck4 = 0 time = 50
* CHECK dout1_10 vdout1_10ck4 = 1.6 time = 50
* CHECK dout1_11 vdout1_11ck4 = 0 time = 50
* CHECK dout1_12 vdout1_12ck4 = 0 time = 50
* CHECK dout1_13 vdout1_13ck4 = 1.6 time = 50
* CHECK dout1_14 vdout1_14ck4 = 0 time = 50
* CHECK dout1_15 vdout1_15ck4 = 1.6 time = 50
* CHECK dout1_16 vdout1_16ck4 = 1.6 time = 50
* CHECK dout1_17 vdout1_17ck4 = 1.6 time = 50
* CHECK dout1_18 vdout1_18ck4 = 0 time = 50
* CHECK dout1_19 vdout1_19ck4 = 0 time = 50
* CHECK dout1_20 vdout1_20ck4 = 0 time = 50
* CHECK dout1_21 vdout1_21ck4 = 1.6 time = 50
* CHECK dout1_22 vdout1_22ck4 = 1.6 time = 50
* CHECK dout1_23 vdout1_23ck4 = 0 time = 50
* CHECK dout1_24 vdout1_24ck4 = 1.6 time = 50
* CHECK dout1_25 vdout1_25ck4 = 1.6 time = 50
* CHECK dout1_26 vdout1_26ck4 = 0 time = 50
* CHECK dout1_27 vdout1_27ck4 = 1.6 time = 50
* CHECK dout1_28 vdout1_28ck4 = 1.6 time = 50
* CHECK dout1_29 vdout1_29ck4 = 0 time = 50
* CHECK dout1_30 vdout1_30ck4 = 1.6 time = 50
* CHECK dout1_31 vdout1_31ck4 = 0 time = 50
* CHECK dout1_32 vdout1_32ck4 = 0 time = 50
* CHECK dout1_0 vdout1_0ck5 = 0 time = 60
* CHECK dout1_1 vdout1_1ck5 = 1.6 time = 60
* CHECK dout1_2 vdout1_2ck5 = 1.6 time = 60
* CHECK dout1_3 vdout1_3ck5 = 0 time = 60
* CHECK dout1_4 vdout1_4ck5 = 0 time = 60
* CHECK dout1_5 vdout1_5ck5 = 0 time = 60
* CHECK dout1_6 vdout1_6ck5 = 1.6 time = 60
* CHECK dout1_7 vdout1_7ck5 = 0 time = 60
* CHECK dout1_8 vdout1_8ck5 = 0 time = 60
* CHECK dout1_9 vdout1_9ck5 = 0 time = 60
* CHECK dout1_10 vdout1_10ck5 = 0 time = 60
* CHECK dout1_11 vdout1_11ck5 = 1.6 time = 60
* CHECK dout1_12 vdout1_12ck5 = 0 time = 60
* CHECK dout1_13 vdout1_13ck5 = 0 time = 60
* CHECK dout1_14 vdout1_14ck5 = 0 time = 60
* CHECK dout1_15 vdout1_15ck5 = 0 time = 60
* CHECK dout1_16 vdout1_16ck5 = 0 time = 60
* CHECK dout1_17 vdout1_17ck5 = 0 time = 60
* CHECK dout1_18 vdout1_18ck5 = 0 time = 60
* CHECK dout1_19 vdout1_19ck5 = 0 time = 60
* CHECK dout1_20 vdout1_20ck5 = 0 time = 60
* CHECK dout1_21 vdout1_21ck5 = 1.6 time = 60
* CHECK dout1_22 vdout1_22ck5 = 1.6 time = 60
* CHECK dout1_23 vdout1_23ck5 = 1.6 time = 60
* CHECK dout1_24 vdout1_24ck5 = 1.6 time = 60
* CHECK dout1_25 vdout1_25ck5 = 1.6 time = 60
* CHECK dout1_26 vdout1_26ck5 = 0 time = 60
* CHECK dout1_27 vdout1_27ck5 = 1.6 time = 60
* CHECK dout1_28 vdout1_28ck5 = 1.6 time = 60
* CHECK dout1_29 vdout1_29ck5 = 1.6 time = 60
* CHECK dout1_30 vdout1_30ck5 = 0 time = 60
* CHECK dout1_31 vdout1_31ck5 = 1.6 time = 60
* CHECK dout1_32 vdout1_32ck5 = 0 time = 60
* CHECK dout1_0 vdout1_0ck6 = 0 time = 70
* CHECK dout1_1 vdout1_1ck6 = 1.6 time = 70
* CHECK dout1_2 vdout1_2ck6 = 1.6 time = 70
* CHECK dout1_3 vdout1_3ck6 = 0 time = 70
* CHECK dout1_4 vdout1_4ck6 = 0 time = 70
* CHECK dout1_5 vdout1_5ck6 = 0 time = 70
* CHECK dout1_6 vdout1_6ck6 = 1.6 time = 70
* CHECK dout1_7 vdout1_7ck6 = 0 time = 70
* CHECK dout1_8 vdout1_8ck6 = 0 time = 70
* CHECK dout1_9 vdout1_9ck6 = 0 time = 70
* CHECK dout1_10 vdout1_10ck6 = 0 time = 70
* CHECK dout1_11 vdout1_11ck6 = 1.6 time = 70
* CHECK dout1_12 vdout1_12ck6 = 0 time = 70
* CHECK dout1_13 vdout1_13ck6 = 0 time = 70
* CHECK dout1_14 vdout1_14ck6 = 0 time = 70
* CHECK dout1_15 vdout1_15ck6 = 0 time = 70
* CHECK dout1_16 vdout1_16ck6 = 0 time = 70
* CHECK dout1_17 vdout1_17ck6 = 0 time = 70
* CHECK dout1_18 vdout1_18ck6 = 0 time = 70
* CHECK dout1_19 vdout1_19ck6 = 0 time = 70
* CHECK dout1_20 vdout1_20ck6 = 0 time = 70
* CHECK dout1_21 vdout1_21ck6 = 1.6 time = 70
* CHECK dout1_22 vdout1_22ck6 = 1.6 time = 70
* CHECK dout1_23 vdout1_23ck6 = 1.6 time = 70
* CHECK dout1_24 vdout1_24ck6 = 1.6 time = 70
* CHECK dout1_25 vdout1_25ck6 = 1.6 time = 70
* CHECK dout1_26 vdout1_26ck6 = 0 time = 70
* CHECK dout1_27 vdout1_27ck6 = 1.6 time = 70
* CHECK dout1_28 vdout1_28ck6 = 1.6 time = 70
* CHECK dout1_29 vdout1_29ck6 = 1.6 time = 70
* CHECK dout1_30 vdout1_30ck6 = 0 time = 70
* CHECK dout1_31 vdout1_31ck6 = 1.6 time = 70
* CHECK dout1_32 vdout1_32ck6 = 0 time = 70
* CHECK dout0_0 vdout0_0ck7 = 0 time = 80
* CHECK dout0_1 vdout0_1ck7 = 0 time = 80
* CHECK dout0_2 vdout0_2ck7 = 0 time = 80
* CHECK dout0_3 vdout0_3ck7 = 0 time = 80
* CHECK dout0_4 vdout0_4ck7 = 0 time = 80
* CHECK dout0_5 vdout0_5ck7 = 1.6 time = 80
* CHECK dout0_6 vdout0_6ck7 = 0 time = 80
* CHECK dout0_7 vdout0_7ck7 = 0 time = 80
* CHECK dout0_8 vdout0_8ck7 = 0 time = 80
* CHECK dout0_9 vdout0_9ck7 = 0 time = 80
* CHECK dout0_10 vdout0_10ck7 = 0 time = 80
* CHECK dout0_11 vdout0_11ck7 = 0 time = 80
* CHECK dout0_12 vdout0_12ck7 = 1.6 time = 80
* CHECK dout0_13 vdout0_13ck7 = 1.6 time = 80
* CHECK dout0_14 vdout0_14ck7 = 0 time = 80
* CHECK dout0_15 vdout0_15ck7 = 1.6 time = 80
* CHECK dout0_16 vdout0_16ck7 = 0 time = 80
* CHECK dout0_17 vdout0_17ck7 = 0 time = 80
* CHECK dout0_18 vdout0_18ck7 = 0 time = 80
* CHECK dout0_19 vdout0_19ck7 = 1.6 time = 80
* CHECK dout0_20 vdout0_20ck7 = 0 time = 80
* CHECK dout0_21 vdout0_21ck7 = 1.6 time = 80
* CHECK dout0_22 vdout0_22ck7 = 0 time = 80
* CHECK dout0_23 vdout0_23ck7 = 0 time = 80
* CHECK dout0_24 vdout0_24ck7 = 0 time = 80
* CHECK dout0_25 vdout0_25ck7 = 1.6 time = 80
* CHECK dout0_26 vdout0_26ck7 = 0 time = 80
* CHECK dout0_27 vdout0_27ck7 = 0 time = 80
* CHECK dout0_28 vdout0_28ck7 = 1.6 time = 80
* CHECK dout0_29 vdout0_29ck7 = 0 time = 80
* CHECK dout0_30 vdout0_30ck7 = 0 time = 80
* CHECK dout0_31 vdout0_31ck7 = 1.6 time = 80
* CHECK dout0_32 vdout0_32ck7 = 0 time = 80
* CHECK dout1_0 vdout1_0ck7 = 0 time = 80
* CHECK dout1_1 vdout1_1ck7 = 0 time = 80
* CHECK dout1_2 vdout1_2ck7 = 0 time = 80
* CHECK dout1_3 vdout1_3ck7 = 0 time = 80
* CHECK dout1_4 vdout1_4ck7 = 0 time = 80
* CHECK dout1_5 vdout1_5ck7 = 1.6 time = 80
* CHECK dout1_6 vdout1_6ck7 = 0 time = 80
* CHECK dout1_7 vdout1_7ck7 = 0 time = 80
* CHECK dout1_8 vdout1_8ck7 = 0 time = 80
* CHECK dout1_9 vdout1_9ck7 = 0 time = 80
* CHECK dout1_10 vdout1_10ck7 = 0 time = 80
* CHECK dout1_11 vdout1_11ck7 = 0 time = 80
* CHECK dout1_12 vdout1_12ck7 = 1.6 time = 80
* CHECK dout1_13 vdout1_13ck7 = 1.6 time = 80
* CHECK dout1_14 vdout1_14ck7 = 0 time = 80
* CHECK dout1_15 vdout1_15ck7 = 1.6 time = 80
* CHECK dout1_16 vdout1_16ck7 = 0 time = 80
* CHECK dout1_17 vdout1_17ck7 = 0 time = 80
* CHECK dout1_18 vdout1_18ck7 = 0 time = 80
* CHECK dout1_19 vdout1_19ck7 = 1.6 time = 80
* CHECK dout1_20 vdout1_20ck7 = 0 time = 80
* CHECK dout1_21 vdout1_21ck7 = 1.6 time = 80
* CHECK dout1_22 vdout1_22ck7 = 0 time = 80
* CHECK dout1_23 vdout1_23ck7 = 0 time = 80
* CHECK dout1_24 vdout1_24ck7 = 0 time = 80
* CHECK dout1_25 vdout1_25ck7 = 1.6 time = 80
* CHECK dout1_26 vdout1_26ck7 = 0 time = 80
* CHECK dout1_27 vdout1_27ck7 = 0 time = 80
* CHECK dout1_28 vdout1_28ck7 = 1.6 time = 80
* CHECK dout1_29 vdout1_29ck7 = 0 time = 80
* CHECK dout1_30 vdout1_30ck7 = 0 time = 80
* CHECK dout1_31 vdout1_31ck7 = 1.6 time = 80
* CHECK dout1_32 vdout1_32ck7 = 0 time = 80
* CHECK dout0_0 vdout0_0ck8 = 0 time = 90
* CHECK dout0_1 vdout0_1ck8 = 0 time = 90
* CHECK dout0_2 vdout0_2ck8 = 0 time = 90
* CHECK dout0_3 vdout0_3ck8 = 0 time = 90
* CHECK dout0_4 vdout0_4ck8 = 0 time = 90
* CHECK dout0_5 vdout0_5ck8 = 1.6 time = 90
* CHECK dout0_6 vdout0_6ck8 = 0 time = 90
* CHECK dout0_7 vdout0_7ck8 = 0 time = 90
* CHECK dout0_8 vdout0_8ck8 = 0 time = 90
* CHECK dout0_9 vdout0_9ck8 = 0 time = 90
* CHECK dout0_10 vdout0_10ck8 = 0 time = 90
* CHECK dout0_11 vdout0_11ck8 = 0 time = 90
* CHECK dout0_12 vdout0_12ck8 = 1.6 time = 90
* CHECK dout0_13 vdout0_13ck8 = 1.6 time = 90
* CHECK dout0_14 vdout0_14ck8 = 0 time = 90
* CHECK dout0_15 vdout0_15ck8 = 1.6 time = 90
* CHECK dout0_16 vdout0_16ck8 = 0 time = 90
* CHECK dout0_17 vdout0_17ck8 = 0 time = 90
* CHECK dout0_18 vdout0_18ck8 = 0 time = 90
* CHECK dout0_19 vdout0_19ck8 = 1.6 time = 90
* CHECK dout0_20 vdout0_20ck8 = 0 time = 90
* CHECK dout0_21 vdout0_21ck8 = 1.6 time = 90
* CHECK dout0_22 vdout0_22ck8 = 0 time = 90
* CHECK dout0_23 vdout0_23ck8 = 0 time = 90
* CHECK dout0_24 vdout0_24ck8 = 0 time = 90
* CHECK dout0_25 vdout0_25ck8 = 1.6 time = 90
* CHECK dout0_26 vdout0_26ck8 = 0 time = 90
* CHECK dout0_27 vdout0_27ck8 = 0 time = 90
* CHECK dout0_28 vdout0_28ck8 = 1.6 time = 90
* CHECK dout0_29 vdout0_29ck8 = 0 time = 90
* CHECK dout0_30 vdout0_30ck8 = 0 time = 90
* CHECK dout0_31 vdout0_31ck8 = 1.6 time = 90
* CHECK dout0_32 vdout0_32ck8 = 0 time = 90
* CHECK dout1_0 vdout1_0ck8 = 0 time = 90
* CHECK dout1_1 vdout1_1ck8 = 0 time = 90
* CHECK dout1_2 vdout1_2ck8 = 0 time = 90
* CHECK dout1_3 vdout1_3ck8 = 0 time = 90
* CHECK dout1_4 vdout1_4ck8 = 0 time = 90
* CHECK dout1_5 vdout1_5ck8 = 1.6 time = 90
* CHECK dout1_6 vdout1_6ck8 = 0 time = 90
* CHECK dout1_7 vdout1_7ck8 = 0 time = 90
* CHECK dout1_8 vdout1_8ck8 = 0 time = 90
* CHECK dout1_9 vdout1_9ck8 = 0 time = 90
* CHECK dout1_10 vdout1_10ck8 = 0 time = 90
* CHECK dout1_11 vdout1_11ck8 = 0 time = 90
* CHECK dout1_12 vdout1_12ck8 = 1.6 time = 90
* CHECK dout1_13 vdout1_13ck8 = 1.6 time = 90
* CHECK dout1_14 vdout1_14ck8 = 0 time = 90
* CHECK dout1_15 vdout1_15ck8 = 1.6 time = 90
* CHECK dout1_16 vdout1_16ck8 = 0 time = 90
* CHECK dout1_17 vdout1_17ck8 = 0 time = 90
* CHECK dout1_18 vdout1_18ck8 = 0 time = 90
* CHECK dout1_19 vdout1_19ck8 = 1.6 time = 90
* CHECK dout1_20 vdout1_20ck8 = 0 time = 90
* CHECK dout1_21 vdout1_21ck8 = 1.6 time = 90
* CHECK dout1_22 vdout1_22ck8 = 0 time = 90
* CHECK dout1_23 vdout1_23ck8 = 0 time = 90
* CHECK dout1_24 vdout1_24ck8 = 0 time = 90
* CHECK dout1_25 vdout1_25ck8 = 1.6 time = 90
* CHECK dout1_26 vdout1_26ck8 = 0 time = 90
* CHECK dout1_27 vdout1_27ck8 = 0 time = 90
* CHECK dout1_28 vdout1_28ck8 = 1.6 time = 90
* CHECK dout1_29 vdout1_29ck8 = 0 time = 90
* CHECK dout1_30 vdout1_30ck8 = 0 time = 90
* CHECK dout1_31 vdout1_31ck8 = 1.6 time = 90
* CHECK dout1_32 vdout1_32ck8 = 0 time = 90
* CHECK dout0_0 vdout0_0ck10 = 0 time = 110
* CHECK dout0_1 vdout0_1ck10 = 1.6 time = 110
* CHECK dout0_2 vdout0_2ck10 = 1.6 time = 110
* CHECK dout0_3 vdout0_3ck10 = 0 time = 110
* CHECK dout0_4 vdout0_4ck10 = 0 time = 110
* CHECK dout0_5 vdout0_5ck10 = 0 time = 110
* CHECK dout0_6 vdout0_6ck10 = 1.6 time = 110
* CHECK dout0_7 vdout0_7ck10 = 0 time = 110
* CHECK dout0_8 vdout0_8ck10 = 0 time = 110
* CHECK dout0_9 vdout0_9ck10 = 0 time = 110
* CHECK dout0_10 vdout0_10ck10 = 0 time = 110
* CHECK dout0_11 vdout0_11ck10 = 1.6 time = 110
* CHECK dout0_12 vdout0_12ck10 = 0 time = 110
* CHECK dout0_13 vdout0_13ck10 = 0 time = 110
* CHECK dout0_14 vdout0_14ck10 = 0 time = 110
* CHECK dout0_15 vdout0_15ck10 = 0 time = 110
* CHECK dout0_16 vdout0_16ck10 = 0 time = 110
* CHECK dout0_17 vdout0_17ck10 = 0 time = 110
* CHECK dout0_18 vdout0_18ck10 = 0 time = 110
* CHECK dout0_19 vdout0_19ck10 = 0 time = 110
* CHECK dout0_20 vdout0_20ck10 = 0 time = 110
* CHECK dout0_21 vdout0_21ck10 = 1.6 time = 110
* CHECK dout0_22 vdout0_22ck10 = 1.6 time = 110
* CHECK dout0_23 vdout0_23ck10 = 1.6 time = 110
* CHECK dout0_24 vdout0_24ck10 = 1.6 time = 110
* CHECK dout0_25 vdout0_25ck10 = 1.6 time = 110
* CHECK dout0_26 vdout0_26ck10 = 0 time = 110
* CHECK dout0_27 vdout0_27ck10 = 1.6 time = 110
* CHECK dout0_28 vdout0_28ck10 = 1.6 time = 110
* CHECK dout0_29 vdout0_29ck10 = 1.6 time = 110
* CHECK dout0_30 vdout0_30ck10 = 0 time = 110
* CHECK dout0_31 vdout0_31ck10 = 1.6 time = 110
* CHECK dout0_32 vdout0_32ck10 = 0 time = 110
* CHECK dout1_0 vdout1_0ck10 = 0 time = 110
* CHECK dout1_1 vdout1_1ck10 = 1.6 time = 110
* CHECK dout1_2 vdout1_2ck10 = 1.6 time = 110
* CHECK dout1_3 vdout1_3ck10 = 0 time = 110
* CHECK dout1_4 vdout1_4ck10 = 0 time = 110
* CHECK dout1_5 vdout1_5ck10 = 0 time = 110
* CHECK dout1_6 vdout1_6ck10 = 1.6 time = 110
* CHECK dout1_7 vdout1_7ck10 = 0 time = 110
* CHECK dout1_8 vdout1_8ck10 = 0 time = 110
* CHECK dout1_9 vdout1_9ck10 = 0 time = 110
* CHECK dout1_10 vdout1_10ck10 = 0 time = 110
* CHECK dout1_11 vdout1_11ck10 = 1.6 time = 110
* CHECK dout1_12 vdout1_12ck10 = 0 time = 110
* CHECK dout1_13 vdout1_13ck10 = 0 time = 110
* CHECK dout1_14 vdout1_14ck10 = 0 time = 110
* CHECK dout1_15 vdout1_15ck10 = 0 time = 110
* CHECK dout1_16 vdout1_16ck10 = 0 time = 110
* CHECK dout1_17 vdout1_17ck10 = 0 time = 110
* CHECK dout1_18 vdout1_18ck10 = 0 time = 110
* CHECK dout1_19 vdout1_19ck10 = 0 time = 110
* CHECK dout1_20 vdout1_20ck10 = 0 time = 110
* CHECK dout1_21 vdout1_21ck10 = 1.6 time = 110
* CHECK dout1_22 vdout1_22ck10 = 1.6 time = 110
* CHECK dout1_23 vdout1_23ck10 = 1.6 time = 110
* CHECK dout1_24 vdout1_24ck10 = 1.6 time = 110
* CHECK dout1_25 vdout1_25ck10 = 1.6 time = 110
* CHECK dout1_26 vdout1_26ck10 = 0 time = 110
* CHECK dout1_27 vdout1_27ck10 = 1.6 time = 110
* CHECK dout1_28 vdout1_28ck10 = 1.6 time = 110
* CHECK dout1_29 vdout1_29ck10 = 1.6 time = 110
* CHECK dout1_30 vdout1_30ck10 = 0 time = 110
* CHECK dout1_31 vdout1_31ck10 = 1.6 time = 110
* CHECK dout1_32 vdout1_32ck10 = 0 time = 110
* CHECK dout0_0 vdout0_0ck12 = 1.6 time = 130
* CHECK dout0_1 vdout0_1ck12 = 0 time = 130
* CHECK dout0_2 vdout0_2ck12 = 0 time = 130
* CHECK dout0_3 vdout0_3ck12 = 1.6 time = 130
* CHECK dout0_4 vdout0_4ck12 = 0 time = 130
* CHECK dout0_5 vdout0_5ck12 = 0 time = 130
* CHECK dout0_6 vdout0_6ck12 = 0 time = 130
* CHECK dout0_7 vdout0_7ck12 = 0 time = 130
* CHECK dout0_8 vdout0_8ck12 = 1.6 time = 130
* CHECK dout0_9 vdout0_9ck12 = 0 time = 130
* CHECK dout0_10 vdout0_10ck12 = 0 time = 130
* CHECK dout0_11 vdout0_11ck12 = 1.6 time = 130
* CHECK dout0_12 vdout0_12ck12 = 1.6 time = 130
* CHECK dout0_13 vdout0_13ck12 = 1.6 time = 130
* CHECK dout0_14 vdout0_14ck12 = 1.6 time = 130
* CHECK dout0_15 vdout0_15ck12 = 0 time = 130
* CHECK dout0_16 vdout0_16ck12 = 1.6 time = 130
* CHECK dout0_17 vdout0_17ck12 = 0 time = 130
* CHECK dout0_18 vdout0_18ck12 = 1.6 time = 130
* CHECK dout0_19 vdout0_19ck12 = 1.6 time = 130
* CHECK dout0_20 vdout0_20ck12 = 1.6 time = 130
* CHECK dout0_21 vdout0_21ck12 = 1.6 time = 130
* CHECK dout0_22 vdout0_22ck12 = 1.6 time = 130
* CHECK dout0_23 vdout0_23ck12 = 0 time = 130
* CHECK dout0_24 vdout0_24ck12 = 1.6 time = 130
* CHECK dout0_25 vdout0_25ck12 = 0 time = 130
* CHECK dout0_26 vdout0_26ck12 = 0 time = 130
* CHECK dout0_27 vdout0_27ck12 = 0 time = 130
* CHECK dout0_28 vdout0_28ck12 = 1.6 time = 130
* CHECK dout0_29 vdout0_29ck12 = 1.6 time = 130
* CHECK dout0_30 vdout0_30ck12 = 1.6 time = 130
* CHECK dout0_31 vdout0_31ck12 = 0 time = 130
* CHECK dout0_32 vdout0_32ck12 = 0 time = 130
* CHECK dout1_0 vdout1_0ck12 = 0 time = 130
* CHECK dout1_1 vdout1_1ck12 = 1.6 time = 130
* CHECK dout1_2 vdout1_2ck12 = 1.6 time = 130
* CHECK dout1_3 vdout1_3ck12 = 0 time = 130
* CHECK dout1_4 vdout1_4ck12 = 0 time = 130
* CHECK dout1_5 vdout1_5ck12 = 0 time = 130
* CHECK dout1_6 vdout1_6ck12 = 1.6 time = 130
* CHECK dout1_7 vdout1_7ck12 = 0 time = 130
* CHECK dout1_8 vdout1_8ck12 = 0 time = 130
* CHECK dout1_9 vdout1_9ck12 = 0 time = 130
* CHECK dout1_10 vdout1_10ck12 = 0 time = 130
* CHECK dout1_11 vdout1_11ck12 = 1.6 time = 130
* CHECK dout1_12 vdout1_12ck12 = 0 time = 130
* CHECK dout1_13 vdout1_13ck12 = 0 time = 130
* CHECK dout1_14 vdout1_14ck12 = 0 time = 130
* CHECK dout1_15 vdout1_15ck12 = 0 time = 130
* CHECK dout1_16 vdout1_16ck12 = 0 time = 130
* CHECK dout1_17 vdout1_17ck12 = 0 time = 130
* CHECK dout1_18 vdout1_18ck12 = 0 time = 130
* CHECK dout1_19 vdout1_19ck12 = 0 time = 130
* CHECK dout1_20 vdout1_20ck12 = 0 time = 130
* CHECK dout1_21 vdout1_21ck12 = 1.6 time = 130
* CHECK dout1_22 vdout1_22ck12 = 1.6 time = 130
* CHECK dout1_23 vdout1_23ck12 = 1.6 time = 130
* CHECK dout1_24 vdout1_24ck12 = 1.6 time = 130
* CHECK dout1_25 vdout1_25ck12 = 1.6 time = 130
* CHECK dout1_26 vdout1_26ck12 = 0 time = 130
* CHECK dout1_27 vdout1_27ck12 = 1.6 time = 130
* CHECK dout1_28 vdout1_28ck12 = 1.6 time = 130
* CHECK dout1_29 vdout1_29ck12 = 1.6 time = 130
* CHECK dout1_30 vdout1_30ck12 = 0 time = 130
* CHECK dout1_31 vdout1_31ck12 = 1.6 time = 130
* CHECK dout1_32 vdout1_32ck12 = 0 time = 130
* CHECK dout0_0 vdout0_0ck14 = 0 time = 150
* CHECK dout0_1 vdout0_1ck14 = 1.6 time = 150
* CHECK dout0_2 vdout0_2ck14 = 1.6 time = 150
* CHECK dout0_3 vdout0_3ck14 = 1.6 time = 150
* CHECK dout0_4 vdout0_4ck14 = 1.6 time = 150
* CHECK dout0_5 vdout0_5ck14 = 1.6 time = 150
* CHECK dout0_6 vdout0_6ck14 = 1.6 time = 150
* CHECK dout0_7 vdout0_7ck14 = 0 time = 150
* CHECK dout0_8 vdout0_8ck14 = 1.6 time = 150
* CHECK dout0_9 vdout0_9ck14 = 0 time = 150
* CHECK dout0_10 vdout0_10ck14 = 1.6 time = 150
* CHECK dout0_11 vdout0_11ck14 = 0 time = 150
* CHECK dout0_12 vdout0_12ck14 = 1.6 time = 150
* CHECK dout0_13 vdout0_13ck14 = 1.6 time = 150
* CHECK dout0_14 vdout0_14ck14 = 0 time = 150
* CHECK dout0_15 vdout0_15ck14 = 1.6 time = 150
* CHECK dout0_16 vdout0_16ck14 = 1.6 time = 150
* CHECK dout0_17 vdout0_17ck14 = 0 time = 150
* CHECK dout0_18 vdout0_18ck14 = 1.6 time = 150
* CHECK dout0_19 vdout0_19ck14 = 1.6 time = 150
* CHECK dout0_20 vdout0_20ck14 = 0 time = 150
* CHECK dout0_21 vdout0_21ck14 = 0 time = 150
* CHECK dout0_22 vdout0_22ck14 = 0 time = 150
* CHECK dout0_23 vdout0_23ck14 = 1.6 time = 150
* CHECK dout0_24 vdout0_24ck14 = 1.6 time = 150
* CHECK dout0_25 vdout0_25ck14 = 1.6 time = 150
* CHECK dout0_26 vdout0_26ck14 = 1.6 time = 150
* CHECK dout0_27 vdout0_27ck14 = 0 time = 150
* CHECK dout0_28 vdout0_28ck14 = 1.6 time = 150
* CHECK dout0_29 vdout0_29ck14 = 1.6 time = 150
* CHECK dout0_30 vdout0_30ck14 = 1.6 time = 150
* CHECK dout0_31 vdout0_31ck14 = 1.6 time = 150
* CHECK dout0_32 vdout0_32ck14 = 0 time = 150
* CHECK dout0_0 vdout0_0ck15 = 1.6 time = 160
* CHECK dout0_1 vdout0_1ck15 = 0 time = 160
* CHECK dout0_2 vdout0_2ck15 = 0 time = 160
* CHECK dout0_3 vdout0_3ck15 = 1.6 time = 160
* CHECK dout0_4 vdout0_4ck15 = 0 time = 160
* CHECK dout0_5 vdout0_5ck15 = 0 time = 160
* CHECK dout0_6 vdout0_6ck15 = 0 time = 160
* CHECK dout0_7 vdout0_7ck15 = 0 time = 160
* CHECK dout0_8 vdout0_8ck15 = 1.6 time = 160
* CHECK dout0_9 vdout0_9ck15 = 0 time = 160
* CHECK dout0_10 vdout0_10ck15 = 0 time = 160
* CHECK dout0_11 vdout0_11ck15 = 1.6 time = 160
* CHECK dout0_12 vdout0_12ck15 = 1.6 time = 160
* CHECK dout0_13 vdout0_13ck15 = 1.6 time = 160
* CHECK dout0_14 vdout0_14ck15 = 1.6 time = 160
* CHECK dout0_15 vdout0_15ck15 = 0 time = 160
* CHECK dout0_16 vdout0_16ck15 = 1.6 time = 160
* CHECK dout0_17 vdout0_17ck15 = 0 time = 160
* CHECK dout0_18 vdout0_18ck15 = 1.6 time = 160
* CHECK dout0_19 vdout0_19ck15 = 1.6 time = 160
* CHECK dout0_20 vdout0_20ck15 = 1.6 time = 160
* CHECK dout0_21 vdout0_21ck15 = 1.6 time = 160
* CHECK dout0_22 vdout0_22ck15 = 1.6 time = 160
* CHECK dout0_23 vdout0_23ck15 = 0 time = 160
* CHECK dout0_24 vdout0_24ck15 = 1.6 time = 160
* CHECK dout0_25 vdout0_25ck15 = 0 time = 160
* CHECK dout0_26 vdout0_26ck15 = 0 time = 160
* CHECK dout0_27 vdout0_27ck15 = 0 time = 160
* CHECK dout0_28 vdout0_28ck15 = 1.6 time = 160
* CHECK dout0_29 vdout0_29ck15 = 1.6 time = 160
* CHECK dout0_30 vdout0_30ck15 = 1.6 time = 160
* CHECK dout0_31 vdout0_31ck15 = 0 time = 160
* CHECK dout0_32 vdout0_32ck15 = 0 time = 160
* CHECK dout1_0 vdout1_0ck15 = 0 time = 160
* CHECK dout1_1 vdout1_1ck15 = 1.6 time = 160
* CHECK dout1_2 vdout1_2ck15 = 1.6 time = 160
* CHECK dout1_3 vdout1_3ck15 = 0 time = 160
* CHECK dout1_4 vdout1_4ck15 = 0 time = 160
* CHECK dout1_5 vdout1_5ck15 = 0 time = 160
* CHECK dout1_6 vdout1_6ck15 = 1.6 time = 160
* CHECK dout1_7 vdout1_7ck15 = 0 time = 160
* CHECK dout1_8 vdout1_8ck15 = 0 time = 160
* CHECK dout1_9 vdout1_9ck15 = 0 time = 160
* CHECK dout1_10 vdout1_10ck15 = 0 time = 160
* CHECK dout1_11 vdout1_11ck15 = 1.6 time = 160
* CHECK dout1_12 vdout1_12ck15 = 0 time = 160
* CHECK dout1_13 vdout1_13ck15 = 0 time = 160
* CHECK dout1_14 vdout1_14ck15 = 0 time = 160
* CHECK dout1_15 vdout1_15ck15 = 0 time = 160
* CHECK dout1_16 vdout1_16ck15 = 0 time = 160
* CHECK dout1_17 vdout1_17ck15 = 0 time = 160
* CHECK dout1_18 vdout1_18ck15 = 0 time = 160
* CHECK dout1_19 vdout1_19ck15 = 0 time = 160
* CHECK dout1_20 vdout1_20ck15 = 0 time = 160
* CHECK dout1_21 vdout1_21ck15 = 1.6 time = 160
* CHECK dout1_22 vdout1_22ck15 = 1.6 time = 160
* CHECK dout1_23 vdout1_23ck15 = 1.6 time = 160
* CHECK dout1_24 vdout1_24ck15 = 1.6 time = 160
* CHECK dout1_25 vdout1_25ck15 = 1.6 time = 160
* CHECK dout1_26 vdout1_26ck15 = 0 time = 160
* CHECK dout1_27 vdout1_27ck15 = 1.6 time = 160
* CHECK dout1_28 vdout1_28ck15 = 1.6 time = 160
* CHECK dout1_29 vdout1_29ck15 = 1.6 time = 160
* CHECK dout1_30 vdout1_30ck15 = 0 time = 160
* CHECK dout1_31 vdout1_31ck15 = 1.6 time = 160
* CHECK dout1_32 vdout1_32ck15 = 0 time = 160
* CHECK dout1_0 vdout1_0ck16 = 0 time = 170
* CHECK dout1_1 vdout1_1ck16 = 1.6 time = 170
* CHECK dout1_2 vdout1_2ck16 = 1.6 time = 170
* CHECK dout1_3 vdout1_3ck16 = 1.6 time = 170
* CHECK dout1_4 vdout1_4ck16 = 1.6 time = 170
* CHECK dout1_5 vdout1_5ck16 = 1.6 time = 170
* CHECK dout1_6 vdout1_6ck16 = 1.6 time = 170
* CHECK dout1_7 vdout1_7ck16 = 0 time = 170
* CHECK dout1_8 vdout1_8ck16 = 1.6 time = 170
* CHECK dout1_9 vdout1_9ck16 = 0 time = 170
* CHECK dout1_10 vdout1_10ck16 = 1.6 time = 170
* CHECK dout1_11 vdout1_11ck16 = 0 time = 170
* CHECK dout1_12 vdout1_12ck16 = 1.6 time = 170
* CHECK dout1_13 vdout1_13ck16 = 1.6 time = 170
* CHECK dout1_14 vdout1_14ck16 = 0 time = 170
* CHECK dout1_15 vdout1_15ck16 = 1.6 time = 170
* CHECK dout1_16 vdout1_16ck16 = 1.6 time = 170
* CHECK dout1_17 vdout1_17ck16 = 0 time = 170
* CHECK dout1_18 vdout1_18ck16 = 1.6 time = 170
* CHECK dout1_19 vdout1_19ck16 = 1.6 time = 170
* CHECK dout1_20 vdout1_20ck16 = 0 time = 170
* CHECK dout1_21 vdout1_21ck16 = 0 time = 170
* CHECK dout1_22 vdout1_22ck16 = 0 time = 170
* CHECK dout1_23 vdout1_23ck16 = 1.6 time = 170
* CHECK dout1_24 vdout1_24ck16 = 1.6 time = 170
* CHECK dout1_25 vdout1_25ck16 = 1.6 time = 170
* CHECK dout1_26 vdout1_26ck16 = 1.6 time = 170
* CHECK dout1_27 vdout1_27ck16 = 0 time = 170
* CHECK dout1_28 vdout1_28ck16 = 1.6 time = 170
* CHECK dout1_29 vdout1_29ck16 = 1.6 time = 170
* CHECK dout1_30 vdout1_30ck16 = 1.6 time = 170
* CHECK dout1_31 vdout1_31ck16 = 1.6 time = 170
* CHECK dout1_32 vdout1_32ck16 = 0 time = 170
* CHECK dout0_0 vdout0_0ck18 = 1.6 time = 190
* CHECK dout0_1 vdout0_1ck18 = 0 time = 190
* CHECK dout0_2 vdout0_2ck18 = 0 time = 190
* CHECK dout0_3 vdout0_3ck18 = 1.6 time = 190
* CHECK dout0_4 vdout0_4ck18 = 0 time = 190
* CHECK dout0_5 vdout0_5ck18 = 0 time = 190
* CHECK dout0_6 vdout0_6ck18 = 0 time = 190
* CHECK dout0_7 vdout0_7ck18 = 0 time = 190
* CHECK dout0_8 vdout0_8ck18 = 1.6 time = 190
* CHECK dout0_9 vdout0_9ck18 = 0 time = 190
* CHECK dout0_10 vdout0_10ck18 = 0 time = 190
* CHECK dout0_11 vdout0_11ck18 = 1.6 time = 190
* CHECK dout0_12 vdout0_12ck18 = 1.6 time = 190
* CHECK dout0_13 vdout0_13ck18 = 1.6 time = 190
* CHECK dout0_14 vdout0_14ck18 = 1.6 time = 190
* CHECK dout0_15 vdout0_15ck18 = 0 time = 190
* CHECK dout0_16 vdout0_16ck18 = 1.6 time = 190
* CHECK dout0_17 vdout0_17ck18 = 0 time = 190
* CHECK dout0_18 vdout0_18ck18 = 1.6 time = 190
* CHECK dout0_19 vdout0_19ck18 = 1.6 time = 190
* CHECK dout0_20 vdout0_20ck18 = 1.6 time = 190
* CHECK dout0_21 vdout0_21ck18 = 1.6 time = 190
* CHECK dout0_22 vdout0_22ck18 = 1.6 time = 190
* CHECK dout0_23 vdout0_23ck18 = 0 time = 190
* CHECK dout0_24 vdout0_24ck18 = 1.6 time = 190
* CHECK dout0_25 vdout0_25ck18 = 0 time = 190
* CHECK dout0_26 vdout0_26ck18 = 0 time = 190
* CHECK dout0_27 vdout0_27ck18 = 0 time = 190
* CHECK dout0_28 vdout0_28ck18 = 1.6 time = 190
* CHECK dout0_29 vdout0_29ck18 = 1.6 time = 190
* CHECK dout0_30 vdout0_30ck18 = 1.6 time = 190
* CHECK dout0_31 vdout0_31ck18 = 0 time = 190
* CHECK dout0_32 vdout0_32ck18 = 0 time = 190
* CHECK dout0_0 vdout0_0ck19 = 0 time = 200
* CHECK dout0_1 vdout0_1ck19 = 1.6 time = 200
* CHECK dout0_2 vdout0_2ck19 = 1.6 time = 200
* CHECK dout0_3 vdout0_3ck19 = 1.6 time = 200
* CHECK dout0_4 vdout0_4ck19 = 1.6 time = 200
* CHECK dout0_5 vdout0_5ck19 = 1.6 time = 200
* CHECK dout0_6 vdout0_6ck19 = 1.6 time = 200
* CHECK dout0_7 vdout0_7ck19 = 0 time = 200
* CHECK dout0_8 vdout0_8ck19 = 1.6 time = 200
* CHECK dout0_9 vdout0_9ck19 = 0 time = 200
* CHECK dout0_10 vdout0_10ck19 = 1.6 time = 200
* CHECK dout0_11 vdout0_11ck19 = 0 time = 200
* CHECK dout0_12 vdout0_12ck19 = 1.6 time = 200
* CHECK dout0_13 vdout0_13ck19 = 1.6 time = 200
* CHECK dout0_14 vdout0_14ck19 = 0 time = 200
* CHECK dout0_15 vdout0_15ck19 = 1.6 time = 200
* CHECK dout0_16 vdout0_16ck19 = 1.6 time = 200
* CHECK dout0_17 vdout0_17ck19 = 0 time = 200
* CHECK dout0_18 vdout0_18ck19 = 1.6 time = 200
* CHECK dout0_19 vdout0_19ck19 = 1.6 time = 200
* CHECK dout0_20 vdout0_20ck19 = 0 time = 200
* CHECK dout0_21 vdout0_21ck19 = 0 time = 200
* CHECK dout0_22 vdout0_22ck19 = 0 time = 200
* CHECK dout0_23 vdout0_23ck19 = 1.6 time = 200
* CHECK dout0_24 vdout0_24ck19 = 1.6 time = 200
* CHECK dout0_25 vdout0_25ck19 = 1.6 time = 200
* CHECK dout0_26 vdout0_26ck19 = 1.6 time = 200
* CHECK dout0_27 vdout0_27ck19 = 0 time = 200
* CHECK dout0_28 vdout0_28ck19 = 1.6 time = 200
* CHECK dout0_29 vdout0_29ck19 = 1.6 time = 200
* CHECK dout0_30 vdout0_30ck19 = 1.6 time = 200
* CHECK dout0_31 vdout0_31ck19 = 1.6 time = 200
* CHECK dout0_32 vdout0_32ck19 = 0 time = 200
* CHECK dout0_0 vdout0_0ck20 = 1.6 time = 210
* CHECK dout0_1 vdout0_1ck20 = 0 time = 210
* CHECK dout0_2 vdout0_2ck20 = 0 time = 210
* CHECK dout0_3 vdout0_3ck20 = 1.6 time = 210
* CHECK dout0_4 vdout0_4ck20 = 0 time = 210
* CHECK dout0_5 vdout0_5ck20 = 0 time = 210
* CHECK dout0_6 vdout0_6ck20 = 0 time = 210
* CHECK dout0_7 vdout0_7ck20 = 0 time = 210
* CHECK dout0_8 vdout0_8ck20 = 1.6 time = 210
* CHECK dout0_9 vdout0_9ck20 = 0 time = 210
* CHECK dout0_10 vdout0_10ck20 = 0 time = 210
* CHECK dout0_11 vdout0_11ck20 = 1.6 time = 210
* CHECK dout0_12 vdout0_12ck20 = 1.6 time = 210
* CHECK dout0_13 vdout0_13ck20 = 1.6 time = 210
* CHECK dout0_14 vdout0_14ck20 = 1.6 time = 210
* CHECK dout0_15 vdout0_15ck20 = 0 time = 210
* CHECK dout0_16 vdout0_16ck20 = 1.6 time = 210
* CHECK dout0_17 vdout0_17ck20 = 0 time = 210
* CHECK dout0_18 vdout0_18ck20 = 1.6 time = 210
* CHECK dout0_19 vdout0_19ck20 = 1.6 time = 210
* CHECK dout0_20 vdout0_20ck20 = 1.6 time = 210
* CHECK dout0_21 vdout0_21ck20 = 1.6 time = 210
* CHECK dout0_22 vdout0_22ck20 = 1.6 time = 210
* CHECK dout0_23 vdout0_23ck20 = 0 time = 210
* CHECK dout0_24 vdout0_24ck20 = 1.6 time = 210
* CHECK dout0_25 vdout0_25ck20 = 0 time = 210
* CHECK dout0_26 vdout0_26ck20 = 0 time = 210
* CHECK dout0_27 vdout0_27ck20 = 0 time = 210
* CHECK dout0_28 vdout0_28ck20 = 1.6 time = 210
* CHECK dout0_29 vdout0_29ck20 = 1.6 time = 210
* CHECK dout0_30 vdout0_30ck20 = 1.6 time = 210
* CHECK dout0_31 vdout0_31ck20 = 0 time = 210
* CHECK dout0_32 vdout0_32ck20 = 0 time = 210
* CHECK dout1_0 vdout1_0ck20 = 0 time = 210
* CHECK dout1_1 vdout1_1ck20 = 1.6 time = 210
* CHECK dout1_2 vdout1_2ck20 = 1.6 time = 210
* CHECK dout1_3 vdout1_3ck20 = 1.6 time = 210
* CHECK dout1_4 vdout1_4ck20 = 1.6 time = 210
* CHECK dout1_5 vdout1_5ck20 = 1.6 time = 210
* CHECK dout1_6 vdout1_6ck20 = 1.6 time = 210
* CHECK dout1_7 vdout1_7ck20 = 0 time = 210
* CHECK dout1_8 vdout1_8ck20 = 1.6 time = 210
* CHECK dout1_9 vdout1_9ck20 = 0 time = 210
* CHECK dout1_10 vdout1_10ck20 = 1.6 time = 210
* CHECK dout1_11 vdout1_11ck20 = 0 time = 210
* CHECK dout1_12 vdout1_12ck20 = 1.6 time = 210
* CHECK dout1_13 vdout1_13ck20 = 1.6 time = 210
* CHECK dout1_14 vdout1_14ck20 = 0 time = 210
* CHECK dout1_15 vdout1_15ck20 = 1.6 time = 210
* CHECK dout1_16 vdout1_16ck20 = 1.6 time = 210
* CHECK dout1_17 vdout1_17ck20 = 0 time = 210
* CHECK dout1_18 vdout1_18ck20 = 1.6 time = 210
* CHECK dout1_19 vdout1_19ck20 = 1.6 time = 210
* CHECK dout1_20 vdout1_20ck20 = 0 time = 210
* CHECK dout1_21 vdout1_21ck20 = 0 time = 210
* CHECK dout1_22 vdout1_22ck20 = 0 time = 210
* CHECK dout1_23 vdout1_23ck20 = 1.6 time = 210
* CHECK dout1_24 vdout1_24ck20 = 1.6 time = 210
* CHECK dout1_25 vdout1_25ck20 = 1.6 time = 210
* CHECK dout1_26 vdout1_26ck20 = 1.6 time = 210
* CHECK dout1_27 vdout1_27ck20 = 0 time = 210
* CHECK dout1_28 vdout1_28ck20 = 1.6 time = 210
* CHECK dout1_29 vdout1_29ck20 = 1.6 time = 210
* CHECK dout1_30 vdout1_30ck20 = 1.6 time = 210
* CHECK dout1_31 vdout1_31ck20 = 1.6 time = 210
* CHECK dout1_32 vdout1_32ck20 = 0 time = 210
* CHECK dout0_0 vdout0_0ck21 = 1.6 time = 220
* CHECK dout0_1 vdout0_1ck21 = 0 time = 220
* CHECK dout0_2 vdout0_2ck21 = 0 time = 220
* CHECK dout0_3 vdout0_3ck21 = 1.6 time = 220
* CHECK dout0_4 vdout0_4ck21 = 0 time = 220
* CHECK dout0_5 vdout0_5ck21 = 0 time = 220
* CHECK dout0_6 vdout0_6ck21 = 0 time = 220
* CHECK dout0_7 vdout0_7ck21 = 0 time = 220
* CHECK dout0_8 vdout0_8ck21 = 1.6 time = 220
* CHECK dout0_9 vdout0_9ck21 = 0 time = 220
* CHECK dout0_10 vdout0_10ck21 = 0 time = 220
* CHECK dout0_11 vdout0_11ck21 = 1.6 time = 220
* CHECK dout0_12 vdout0_12ck21 = 1.6 time = 220
* CHECK dout0_13 vdout0_13ck21 = 1.6 time = 220
* CHECK dout0_14 vdout0_14ck21 = 1.6 time = 220
* CHECK dout0_15 vdout0_15ck21 = 0 time = 220
* CHECK dout0_16 vdout0_16ck21 = 1.6 time = 220
* CHECK dout0_17 vdout0_17ck21 = 0 time = 220
* CHECK dout0_18 vdout0_18ck21 = 1.6 time = 220
* CHECK dout0_19 vdout0_19ck21 = 1.6 time = 220
* CHECK dout0_20 vdout0_20ck21 = 1.6 time = 220
* CHECK dout0_21 vdout0_21ck21 = 1.6 time = 220
* CHECK dout0_22 vdout0_22ck21 = 1.6 time = 220
* CHECK dout0_23 vdout0_23ck21 = 0 time = 220
* CHECK dout0_24 vdout0_24ck21 = 1.6 time = 220
* CHECK dout0_25 vdout0_25ck21 = 0 time = 220
* CHECK dout0_26 vdout0_26ck21 = 0 time = 220
* CHECK dout0_27 vdout0_27ck21 = 0 time = 220
* CHECK dout0_28 vdout0_28ck21 = 1.6 time = 220
* CHECK dout0_29 vdout0_29ck21 = 1.6 time = 220
* CHECK dout0_30 vdout0_30ck21 = 1.6 time = 220
* CHECK dout0_31 vdout0_31ck21 = 0 time = 220
* CHECK dout0_32 vdout0_32ck21 = 0 time = 220
* CHECK dout1_0 vdout1_0ck22 = 1.6 time = 230
* CHECK dout1_1 vdout1_1ck22 = 0 time = 230
* CHECK dout1_2 vdout1_2ck22 = 0 time = 230
* CHECK dout1_3 vdout1_3ck22 = 1.6 time = 230
* CHECK dout1_4 vdout1_4ck22 = 0 time = 230
* CHECK dout1_5 vdout1_5ck22 = 0 time = 230
* CHECK dout1_6 vdout1_6ck22 = 0 time = 230
* CHECK dout1_7 vdout1_7ck22 = 0 time = 230
* CHECK dout1_8 vdout1_8ck22 = 1.6 time = 230
* CHECK dout1_9 vdout1_9ck22 = 0 time = 230
* CHECK dout1_10 vdout1_10ck22 = 0 time = 230
* CHECK dout1_11 vdout1_11ck22 = 1.6 time = 230
* CHECK dout1_12 vdout1_12ck22 = 1.6 time = 230
* CHECK dout1_13 vdout1_13ck22 = 1.6 time = 230
* CHECK dout1_14 vdout1_14ck22 = 1.6 time = 230
* CHECK dout1_15 vdout1_15ck22 = 0 time = 230
* CHECK dout1_16 vdout1_16ck22 = 1.6 time = 230
* CHECK dout1_17 vdout1_17ck22 = 0 time = 230
* CHECK dout1_18 vdout1_18ck22 = 1.6 time = 230
* CHECK dout1_19 vdout1_19ck22 = 1.6 time = 230
* CHECK dout1_20 vdout1_20ck22 = 1.6 time = 230
* CHECK dout1_21 vdout1_21ck22 = 1.6 time = 230
* CHECK dout1_22 vdout1_22ck22 = 1.6 time = 230
* CHECK dout1_23 vdout1_23ck22 = 0 time = 230
* CHECK dout1_24 vdout1_24ck22 = 1.6 time = 230
* CHECK dout1_25 vdout1_25ck22 = 0 time = 230
* CHECK dout1_26 vdout1_26ck22 = 0 time = 230
* CHECK dout1_27 vdout1_27ck22 = 0 time = 230
* CHECK dout1_28 vdout1_28ck22 = 1.6 time = 230
* CHECK dout1_29 vdout1_29ck22 = 1.6 time = 230
* CHECK dout1_30 vdout1_30ck22 = 1.6 time = 230
* CHECK dout1_31 vdout1_31ck22 = 0 time = 230
* CHECK dout1_32 vdout1_32ck22 = 0 time = 230
* CHECK dout0_0 vdout0_0ck23 = 1.6 time = 240
* CHECK dout0_1 vdout0_1ck23 = 0 time = 240
* CHECK dout0_2 vdout0_2ck23 = 0 time = 240
* CHECK dout0_3 vdout0_3ck23 = 1.6 time = 240
* CHECK dout0_4 vdout0_4ck23 = 0 time = 240
* CHECK dout0_5 vdout0_5ck23 = 0 time = 240
* CHECK dout0_6 vdout0_6ck23 = 0 time = 240
* CHECK dout0_7 vdout0_7ck23 = 0 time = 240
* CHECK dout0_8 vdout0_8ck23 = 1.6 time = 240
* CHECK dout0_9 vdout0_9ck23 = 0 time = 240
* CHECK dout0_10 vdout0_10ck23 = 0 time = 240
* CHECK dout0_11 vdout0_11ck23 = 1.6 time = 240
* CHECK dout0_12 vdout0_12ck23 = 1.6 time = 240
* CHECK dout0_13 vdout0_13ck23 = 1.6 time = 240
* CHECK dout0_14 vdout0_14ck23 = 1.6 time = 240
* CHECK dout0_15 vdout0_15ck23 = 0 time = 240
* CHECK dout0_16 vdout0_16ck23 = 1.6 time = 240
* CHECK dout0_17 vdout0_17ck23 = 0 time = 240
* CHECK dout0_18 vdout0_18ck23 = 1.6 time = 240
* CHECK dout0_19 vdout0_19ck23 = 1.6 time = 240
* CHECK dout0_20 vdout0_20ck23 = 1.6 time = 240
* CHECK dout0_21 vdout0_21ck23 = 1.6 time = 240
* CHECK dout0_22 vdout0_22ck23 = 1.6 time = 240
* CHECK dout0_23 vdout0_23ck23 = 0 time = 240
* CHECK dout0_24 vdout0_24ck23 = 1.6 time = 240
* CHECK dout0_25 vdout0_25ck23 = 0 time = 240
* CHECK dout0_26 vdout0_26ck23 = 0 time = 240
* CHECK dout0_27 vdout0_27ck23 = 0 time = 240
* CHECK dout0_28 vdout0_28ck23 = 1.6 time = 240
* CHECK dout0_29 vdout0_29ck23 = 1.6 time = 240
* CHECK dout0_30 vdout0_30ck23 = 1.6 time = 240
* CHECK dout0_31 vdout0_31ck23 = 0 time = 240
* CHECK dout0_32 vdout0_32ck23 = 0 time = 240
* CHECK dout1_0 vdout1_0ck25 = 1.6 time = 260
* CHECK dout1_1 vdout1_1ck25 = 0 time = 260
* CHECK dout1_2 vdout1_2ck25 = 1.6 time = 260
* CHECK dout1_3 vdout1_3ck25 = 1.6 time = 260
* CHECK dout1_4 vdout1_4ck25 = 1.6 time = 260
* CHECK dout1_5 vdout1_5ck25 = 0 time = 260
* CHECK dout1_6 vdout1_6ck25 = 0 time = 260
* CHECK dout1_7 vdout1_7ck25 = 0 time = 260
* CHECK dout1_8 vdout1_8ck25 = 0 time = 260
* CHECK dout1_9 vdout1_9ck25 = 1.6 time = 260
* CHECK dout1_10 vdout1_10ck25 = 0 time = 260
* CHECK dout1_11 vdout1_11ck25 = 1.6 time = 260
* CHECK dout1_12 vdout1_12ck25 = 0 time = 260
* CHECK dout1_13 vdout1_13ck25 = 1.6 time = 260
* CHECK dout1_14 vdout1_14ck25 = 0 time = 260
* CHECK dout1_15 vdout1_15ck25 = 1.6 time = 260
* CHECK dout1_16 vdout1_16ck25 = 0 time = 260
* CHECK dout1_17 vdout1_17ck25 = 0 time = 260
* CHECK dout1_18 vdout1_18ck25 = 1.6 time = 260
* CHECK dout1_19 vdout1_19ck25 = 0 time = 260
* CHECK dout1_20 vdout1_20ck25 = 0 time = 260
* CHECK dout1_21 vdout1_21ck25 = 0 time = 260
* CHECK dout1_22 vdout1_22ck25 = 0 time = 260
* CHECK dout1_23 vdout1_23ck25 = 1.6 time = 260
* CHECK dout1_24 vdout1_24ck25 = 0 time = 260
* CHECK dout1_25 vdout1_25ck25 = 1.6 time = 260
* CHECK dout1_26 vdout1_26ck25 = 0 time = 260
* CHECK dout1_27 vdout1_27ck25 = 1.6 time = 260
* CHECK dout1_28 vdout1_28ck25 = 1.6 time = 260
* CHECK dout1_29 vdout1_29ck25 = 1.6 time = 260
* CHECK dout1_30 vdout1_30ck25 = 0 time = 260
* CHECK dout1_31 vdout1_31ck25 = 1.6 time = 260
* CHECK dout1_32 vdout1_32ck25 = 0 time = 260
* CHECK dout0_0 vdout0_0ck27 = 1.6 time = 280
* CHECK dout0_1 vdout0_1ck27 = 1.6 time = 280
* CHECK dout0_2 vdout0_2ck27 = 1.6 time = 280
* CHECK dout0_3 vdout0_3ck27 = 1.6 time = 280
* CHECK dout0_4 vdout0_4ck27 = 1.6 time = 280
* CHECK dout0_5 vdout0_5ck27 = 1.6 time = 280
* CHECK dout0_6 vdout0_6ck27 = 0 time = 280
* CHECK dout0_7 vdout0_7ck27 = 1.6 time = 280
* CHECK dout0_8 vdout0_8ck27 = 1.6 time = 280
* CHECK dout0_9 vdout0_9ck27 = 0 time = 280
* CHECK dout0_10 vdout0_10ck27 = 0 time = 280
* CHECK dout0_11 vdout0_11ck27 = 0 time = 280
* CHECK dout0_12 vdout0_12ck27 = 1.6 time = 280
* CHECK dout0_13 vdout0_13ck27 = 0 time = 280
* CHECK dout0_14 vdout0_14ck27 = 1.6 time = 280
* CHECK dout0_15 vdout0_15ck27 = 0 time = 280
* CHECK dout0_16 vdout0_16ck27 = 0 time = 280
* CHECK dout0_17 vdout0_17ck27 = 0 time = 280
* CHECK dout0_18 vdout0_18ck27 = 1.6 time = 280
* CHECK dout0_19 vdout0_19ck27 = 0 time = 280
* CHECK dout0_20 vdout0_20ck27 = 0 time = 280
* CHECK dout0_21 vdout0_21ck27 = 1.6 time = 280
* CHECK dout0_22 vdout0_22ck27 = 0 time = 280
* CHECK dout0_23 vdout0_23ck27 = 1.6 time = 280
* CHECK dout0_24 vdout0_24ck27 = 1.6 time = 280
* CHECK dout0_25 vdout0_25ck27 = 1.6 time = 280
* CHECK dout0_26 vdout0_26ck27 = 0 time = 280
* CHECK dout0_27 vdout0_27ck27 = 1.6 time = 280
* CHECK dout0_28 vdout0_28ck27 = 1.6 time = 280
* CHECK dout0_29 vdout0_29ck27 = 0 time = 280
* CHECK dout0_30 vdout0_30ck27 = 1.6 time = 280
* CHECK dout0_31 vdout0_31ck27 = 1.6 time = 280
* CHECK dout0_32 vdout0_32ck27 = 0 time = 280
* CHECK dout1_0 vdout1_0ck27 = 1.6 time = 280
* CHECK dout1_1 vdout1_1ck27 = 0 time = 280
* CHECK dout1_2 vdout1_2ck27 = 0 time = 280
* CHECK dout1_3 vdout1_3ck27 = 1.6 time = 280
* CHECK dout1_4 vdout1_4ck27 = 0 time = 280
* CHECK dout1_5 vdout1_5ck27 = 0 time = 280
* CHECK dout1_6 vdout1_6ck27 = 0 time = 280
* CHECK dout1_7 vdout1_7ck27 = 0 time = 280
* CHECK dout1_8 vdout1_8ck27 = 1.6 time = 280
* CHECK dout1_9 vdout1_9ck27 = 0 time = 280
* CHECK dout1_10 vdout1_10ck27 = 0 time = 280
* CHECK dout1_11 vdout1_11ck27 = 1.6 time = 280
* CHECK dout1_12 vdout1_12ck27 = 1.6 time = 280
* CHECK dout1_13 vdout1_13ck27 = 1.6 time = 280
* CHECK dout1_14 vdout1_14ck27 = 1.6 time = 280
* CHECK dout1_15 vdout1_15ck27 = 0 time = 280
* CHECK dout1_16 vdout1_16ck27 = 1.6 time = 280
* CHECK dout1_17 vdout1_17ck27 = 0 time = 280
* CHECK dout1_18 vdout1_18ck27 = 1.6 time = 280
* CHECK dout1_19 vdout1_19ck27 = 1.6 time = 280
* CHECK dout1_20 vdout1_20ck27 = 1.6 time = 280
* CHECK dout1_21 vdout1_21ck27 = 1.6 time = 280
* CHECK dout1_22 vdout1_22ck27 = 1.6 time = 280
* CHECK dout1_23 vdout1_23ck27 = 0 time = 280
* CHECK dout1_24 vdout1_24ck27 = 1.6 time = 280
* CHECK dout1_25 vdout1_25ck27 = 0 time = 280
* CHECK dout1_26 vdout1_26ck27 = 0 time = 280
* CHECK dout1_27 vdout1_27ck27 = 0 time = 280
* CHECK dout1_28 vdout1_28ck27 = 1.6 time = 280
* CHECK dout1_29 vdout1_29ck27 = 1.6 time = 280
* CHECK dout1_30 vdout1_30ck27 = 1.6 time = 280
* CHECK dout1_31 vdout1_31ck27 = 0 time = 280
* CHECK dout1_32 vdout1_32ck27 = 0 time = 280
* CHECK dout1_0 vdout1_0ck28 = 1.6 time = 290
* CHECK dout1_1 vdout1_1ck28 = 1.6 time = 290
* CHECK dout1_2 vdout1_2ck28 = 1.6 time = 290
* CHECK dout1_3 vdout1_3ck28 = 1.6 time = 290
* CHECK dout1_4 vdout1_4ck28 = 1.6 time = 290
* CHECK dout1_5 vdout1_5ck28 = 1.6 time = 290
* CHECK dout1_6 vdout1_6ck28 = 0 time = 290
* CHECK dout1_7 vdout1_7ck28 = 1.6 time = 290
* CHECK dout1_8 vdout1_8ck28 = 1.6 time = 290
* CHECK dout1_9 vdout1_9ck28 = 0 time = 290
* CHECK dout1_10 vdout1_10ck28 = 0 time = 290
* CHECK dout1_11 vdout1_11ck28 = 0 time = 290
* CHECK dout1_12 vdout1_12ck28 = 1.6 time = 290
* CHECK dout1_13 vdout1_13ck28 = 0 time = 290
* CHECK dout1_14 vdout1_14ck28 = 1.6 time = 290
* CHECK dout1_15 vdout1_15ck28 = 0 time = 290
* CHECK dout1_16 vdout1_16ck28 = 0 time = 290
* CHECK dout1_17 vdout1_17ck28 = 0 time = 290
* CHECK dout1_18 vdout1_18ck28 = 1.6 time = 290
* CHECK dout1_19 vdout1_19ck28 = 0 time = 290
* CHECK dout1_20 vdout1_20ck28 = 0 time = 290
* CHECK dout1_21 vdout1_21ck28 = 1.6 time = 290
* CHECK dout1_22 vdout1_22ck28 = 0 time = 290
* CHECK dout1_23 vdout1_23ck28 = 1.6 time = 290
* CHECK dout1_24 vdout1_24ck28 = 1.6 time = 290
* CHECK dout1_25 vdout1_25ck28 = 1.6 time = 290
* CHECK dout1_26 vdout1_26ck28 = 0 time = 290
* CHECK dout1_27 vdout1_27ck28 = 1.6 time = 290
* CHECK dout1_28 vdout1_28ck28 = 1.6 time = 290
* CHECK dout1_29 vdout1_29ck28 = 0 time = 290
* CHECK dout1_30 vdout1_30ck28 = 1.6 time = 290
* CHECK dout1_31 vdout1_31ck28 = 1.6 time = 290
* CHECK dout1_32 vdout1_32ck28 = 0 time = 290
* CHECK dout0_0 vdout0_0ck32 = 0 time = 330
* CHECK dout0_1 vdout0_1ck32 = 0 time = 330
* CHECK dout0_2 vdout0_2ck32 = 0 time = 330
* CHECK dout0_3 vdout0_3ck32 = 0 time = 330
* CHECK dout0_4 vdout0_4ck32 = 1.6 time = 330
* CHECK dout0_5 vdout0_5ck32 = 0 time = 330
* CHECK dout0_6 vdout0_6ck32 = 0 time = 330
* CHECK dout0_7 vdout0_7ck32 = 1.6 time = 330
* CHECK dout0_8 vdout0_8ck32 = 0 time = 330
* CHECK dout0_9 vdout0_9ck32 = 0 time = 330
* CHECK dout0_10 vdout0_10ck32 = 1.6 time = 330
* CHECK dout0_11 vdout0_11ck32 = 1.6 time = 330
* CHECK dout0_12 vdout0_12ck32 = 1.6 time = 330
* CHECK dout0_13 vdout0_13ck32 = 1.6 time = 330
* CHECK dout0_14 vdout0_14ck32 = 1.6 time = 330
* CHECK dout0_15 vdout0_15ck32 = 0 time = 330
* CHECK dout0_16 vdout0_16ck32 = 0 time = 330
* CHECK dout0_17 vdout0_17ck32 = 0 time = 330
* CHECK dout0_18 vdout0_18ck32 = 0 time = 330
* CHECK dout0_19 vdout0_19ck32 = 0 time = 330
* CHECK dout0_20 vdout0_20ck32 = 0 time = 330
* CHECK dout0_21 vdout0_21ck32 = 1.6 time = 330
* CHECK dout0_22 vdout0_22ck32 = 1.6 time = 330
* CHECK dout0_23 vdout0_23ck32 = 0 time = 330
* CHECK dout0_24 vdout0_24ck32 = 0 time = 330
* CHECK dout0_25 vdout0_25ck32 = 1.6 time = 330
* CHECK dout0_26 vdout0_26ck32 = 1.6 time = 330
* CHECK dout0_27 vdout0_27ck32 = 1.6 time = 330
* CHECK dout0_28 vdout0_28ck32 = 0 time = 330
* CHECK dout0_29 vdout0_29ck32 = 0 time = 330
* CHECK dout0_30 vdout0_30ck32 = 1.6 time = 330
* CHECK dout0_31 vdout0_31ck32 = 1.6 time = 330
* CHECK dout0_32 vdout0_32ck32 = 0 time = 330
* CHECK dout0_0 vdout0_0ck33 = 1.6 time = 340
* CHECK dout0_1 vdout0_1ck33 = 0 time = 340
* CHECK dout0_2 vdout0_2ck33 = 1.6 time = 340
* CHECK dout0_3 vdout0_3ck33 = 1.6 time = 340
* CHECK dout0_4 vdout0_4ck33 = 1.6 time = 340
* CHECK dout0_5 vdout0_5ck33 = 0 time = 340
* CHECK dout0_6 vdout0_6ck33 = 0 time = 340
* CHECK dout0_7 vdout0_7ck33 = 0 time = 340
* CHECK dout0_8 vdout0_8ck33 = 0 time = 340
* CHECK dout0_9 vdout0_9ck33 = 1.6 time = 340
* CHECK dout0_10 vdout0_10ck33 = 0 time = 340
* CHECK dout0_11 vdout0_11ck33 = 1.6 time = 340
* CHECK dout0_12 vdout0_12ck33 = 0 time = 340
* CHECK dout0_13 vdout0_13ck33 = 1.6 time = 340
* CHECK dout0_14 vdout0_14ck33 = 0 time = 340
* CHECK dout0_15 vdout0_15ck33 = 1.6 time = 340
* CHECK dout0_16 vdout0_16ck33 = 0 time = 340
* CHECK dout0_17 vdout0_17ck33 = 0 time = 340
* CHECK dout0_18 vdout0_18ck33 = 1.6 time = 340
* CHECK dout0_19 vdout0_19ck33 = 0 time = 340
* CHECK dout0_20 vdout0_20ck33 = 0 time = 340
* CHECK dout0_21 vdout0_21ck33 = 0 time = 340
* CHECK dout0_22 vdout0_22ck33 = 0 time = 340
* CHECK dout0_23 vdout0_23ck33 = 1.6 time = 340
* CHECK dout0_24 vdout0_24ck33 = 0 time = 340
* CHECK dout0_25 vdout0_25ck33 = 1.6 time = 340
* CHECK dout0_26 vdout0_26ck33 = 0 time = 340
* CHECK dout0_27 vdout0_27ck33 = 1.6 time = 340
* CHECK dout0_28 vdout0_28ck33 = 1.6 time = 340
* CHECK dout0_29 vdout0_29ck33 = 1.6 time = 340
* CHECK dout0_30 vdout0_30ck33 = 0 time = 340
* CHECK dout0_31 vdout0_31ck33 = 1.6 time = 340
* CHECK dout0_32 vdout0_32ck33 = 0 time = 340
* CHECK dout1_0 vdout1_0ck35 = 0 time = 360
* CHECK dout1_1 vdout1_1ck35 = 0 time = 360
* CHECK dout1_2 vdout1_2ck35 = 0 time = 360
* CHECK dout1_3 vdout1_3ck35 = 1.6 time = 360
* CHECK dout1_4 vdout1_4ck35 = 0 time = 360
* CHECK dout1_5 vdout1_5ck35 = 0 time = 360
* CHECK dout1_6 vdout1_6ck35 = 1.6 time = 360
* CHECK dout1_7 vdout1_7ck35 = 0 time = 360
* CHECK dout1_8 vdout1_8ck35 = 1.6 time = 360
* CHECK dout1_9 vdout1_9ck35 = 1.6 time = 360
* CHECK dout1_10 vdout1_10ck35 = 0 time = 360
* CHECK dout1_11 vdout1_11ck35 = 0 time = 360
* CHECK dout1_12 vdout1_12ck35 = 1.6 time = 360
* CHECK dout1_13 vdout1_13ck35 = 1.6 time = 360
* CHECK dout1_14 vdout1_14ck35 = 1.6 time = 360
* CHECK dout1_15 vdout1_15ck35 = 1.6 time = 360
* CHECK dout1_16 vdout1_16ck35 = 0 time = 360
* CHECK dout1_17 vdout1_17ck35 = 1.6 time = 360
* CHECK dout1_18 vdout1_18ck35 = 1.6 time = 360
* CHECK dout1_19 vdout1_19ck35 = 1.6 time = 360
* CHECK dout1_20 vdout1_20ck35 = 0 time = 360
* CHECK dout1_21 vdout1_21ck35 = 0 time = 360
* CHECK dout1_22 vdout1_22ck35 = 1.6 time = 360
* CHECK dout1_23 vdout1_23ck35 = 0 time = 360
* CHECK dout1_24 vdout1_24ck35 = 1.6 time = 360
* CHECK dout1_25 vdout1_25ck35 = 1.6 time = 360
* CHECK dout1_26 vdout1_26ck35 = 0 time = 360
* CHECK dout1_27 vdout1_27ck35 = 0 time = 360
* CHECK dout1_28 vdout1_28ck35 = 0 time = 360
* CHECK dout1_29 vdout1_29ck35 = 1.6 time = 360
* CHECK dout1_30 vdout1_30ck35 = 1.6 time = 360
* CHECK dout1_31 vdout1_31ck35 = 0 time = 360
* CHECK dout1_32 vdout1_32ck35 = 0 time = 360
* CHECK dout1_0 vdout1_0ck37 = 0 time = 380
* CHECK dout1_1 vdout1_1ck37 = 0 time = 380
* CHECK dout1_2 vdout1_2ck37 = 0 time = 380
* CHECK dout1_3 vdout1_3ck37 = 0 time = 380
* CHECK dout1_4 vdout1_4ck37 = 0 time = 380
* CHECK dout1_5 vdout1_5ck37 = 1.6 time = 380
* CHECK dout1_6 vdout1_6ck37 = 0 time = 380
* CHECK dout1_7 vdout1_7ck37 = 0 time = 380
* CHECK dout1_8 vdout1_8ck37 = 0 time = 380
* CHECK dout1_9 vdout1_9ck37 = 0 time = 380
* CHECK dout1_10 vdout1_10ck37 = 0 time = 380
* CHECK dout1_11 vdout1_11ck37 = 1.6 time = 380
* CHECK dout1_12 vdout1_12ck37 = 1.6 time = 380
* CHECK dout1_13 vdout1_13ck37 = 1.6 time = 380
* CHECK dout1_14 vdout1_14ck37 = 0 time = 380
* CHECK dout1_15 vdout1_15ck37 = 0 time = 380
* CHECK dout1_16 vdout1_16ck37 = 0 time = 380
* CHECK dout1_17 vdout1_17ck37 = 1.6 time = 380
* CHECK dout1_18 vdout1_18ck37 = 0 time = 380
* CHECK dout1_19 vdout1_19ck37 = 0 time = 380
* CHECK dout1_20 vdout1_20ck37 = 1.6 time = 380
* CHECK dout1_21 vdout1_21ck37 = 0 time = 380
* CHECK dout1_22 vdout1_22ck37 = 1.6 time = 380
* CHECK dout1_23 vdout1_23ck37 = 1.6 time = 380
* CHECK dout1_24 vdout1_24ck37 = 1.6 time = 380
* CHECK dout1_25 vdout1_25ck37 = 0 time = 380
* CHECK dout1_26 vdout1_26ck37 = 1.6 time = 380
* CHECK dout1_27 vdout1_27ck37 = 0 time = 380
* CHECK dout1_28 vdout1_28ck37 = 1.6 time = 380
* CHECK dout1_29 vdout1_29ck37 = 0 time = 380
* CHECK dout1_30 vdout1_30ck37 = 1.6 time = 380
* CHECK dout1_31 vdout1_31ck37 = 0 time = 380
* CHECK dout1_32 vdout1_32ck37 = 0 time = 380
* CHECK dout0_0 vdout0_0ck39 = 0 time = 400
* CHECK dout0_1 vdout0_1ck39 = 1.6 time = 400
* CHECK dout0_2 vdout0_2ck39 = 1.6 time = 400
* CHECK dout0_3 vdout0_3ck39 = 0 time = 400
* CHECK dout0_4 vdout0_4ck39 = 0 time = 400
* CHECK dout0_5 vdout0_5ck39 = 1.6 time = 400
* CHECK dout0_6 vdout0_6ck39 = 1.6 time = 400
* CHECK dout0_7 vdout0_7ck39 = 1.6 time = 400
* CHECK dout0_8 vdout0_8ck39 = 1.6 time = 400
* CHECK dout0_9 vdout0_9ck39 = 0 time = 400
* CHECK dout0_10 vdout0_10ck39 = 0 time = 400
* CHECK dout0_11 vdout0_11ck39 = 1.6 time = 400
* CHECK dout0_12 vdout0_12ck39 = 0 time = 400
* CHECK dout0_13 vdout0_13ck39 = 0 time = 400
* CHECK dout0_14 vdout0_14ck39 = 0 time = 400
* CHECK dout0_15 vdout0_15ck39 = 0 time = 400
* CHECK dout0_16 vdout0_16ck39 = 1.6 time = 400
* CHECK dout0_17 vdout0_17ck39 = 0 time = 400
* CHECK dout0_18 vdout0_18ck39 = 0 time = 400
* CHECK dout0_19 vdout0_19ck39 = 1.6 time = 400
* CHECK dout0_20 vdout0_20ck39 = 0 time = 400
* CHECK dout0_21 vdout0_21ck39 = 0 time = 400
* CHECK dout0_22 vdout0_22ck39 = 0 time = 400
* CHECK dout0_23 vdout0_23ck39 = 1.6 time = 400
* CHECK dout0_24 vdout0_24ck39 = 1.6 time = 400
* CHECK dout0_25 vdout0_25ck39 = 0 time = 400
* CHECK dout0_26 vdout0_26ck39 = 1.6 time = 400
* CHECK dout0_27 vdout0_27ck39 = 0 time = 400
* CHECK dout0_28 vdout0_28ck39 = 0 time = 400
* CHECK dout0_29 vdout0_29ck39 = 0 time = 400
* CHECK dout0_30 vdout0_30ck39 = 1.6 time = 400
* CHECK dout0_31 vdout0_31ck39 = 1.6 time = 400
* CHECK dout0_32 vdout0_32ck39 = 0 time = 400
* CHECK dout1_0 vdout1_0ck40 = 1.6 time = 410
* CHECK dout1_1 vdout1_1ck40 = 0 time = 410
* CHECK dout1_2 vdout1_2ck40 = 1.6 time = 410
* CHECK dout1_3 vdout1_3ck40 = 1.6 time = 410
* CHECK dout1_4 vdout1_4ck40 = 1.6 time = 410
* CHECK dout1_5 vdout1_5ck40 = 0 time = 410
* CHECK dout1_6 vdout1_6ck40 = 0 time = 410
* CHECK dout1_7 vdout1_7ck40 = 0 time = 410
* CHECK dout1_8 vdout1_8ck40 = 0 time = 410
* CHECK dout1_9 vdout1_9ck40 = 1.6 time = 410
* CHECK dout1_10 vdout1_10ck40 = 0 time = 410
* CHECK dout1_11 vdout1_11ck40 = 1.6 time = 410
* CHECK dout1_12 vdout1_12ck40 = 0 time = 410
* CHECK dout1_13 vdout1_13ck40 = 1.6 time = 410
* CHECK dout1_14 vdout1_14ck40 = 0 time = 410
* CHECK dout1_15 vdout1_15ck40 = 1.6 time = 410
* CHECK dout1_16 vdout1_16ck40 = 0 time = 410
* CHECK dout1_17 vdout1_17ck40 = 0 time = 410
* CHECK dout1_18 vdout1_18ck40 = 1.6 time = 410
* CHECK dout1_19 vdout1_19ck40 = 0 time = 410
* CHECK dout1_20 vdout1_20ck40 = 0 time = 410
* CHECK dout1_21 vdout1_21ck40 = 0 time = 410
* CHECK dout1_22 vdout1_22ck40 = 0 time = 410
* CHECK dout1_23 vdout1_23ck40 = 1.6 time = 410
* CHECK dout1_24 vdout1_24ck40 = 0 time = 410
* CHECK dout1_25 vdout1_25ck40 = 1.6 time = 410
* CHECK dout1_26 vdout1_26ck40 = 0 time = 410
* CHECK dout1_27 vdout1_27ck40 = 1.6 time = 410
* CHECK dout1_28 vdout1_28ck40 = 1.6 time = 410
* CHECK dout1_29 vdout1_29ck40 = 1.6 time = 410
* CHECK dout1_30 vdout1_30ck40 = 0 time = 410
* CHECK dout1_31 vdout1_31ck40 = 1.6 time = 410
* CHECK dout1_32 vdout1_32ck40 = 0 time = 410
* CHECK dout0_0 vdout0_0ck41 = 1.6 time = 420
* CHECK dout0_1 vdout0_1ck41 = 0 time = 420
* CHECK dout0_2 vdout0_2ck41 = 0 time = 420
* CHECK dout0_3 vdout0_3ck41 = 1.6 time = 420
* CHECK dout0_4 vdout0_4ck41 = 1.6 time = 420
* CHECK dout0_5 vdout0_5ck41 = 1.6 time = 420
* CHECK dout0_6 vdout0_6ck41 = 0 time = 420
* CHECK dout0_7 vdout0_7ck41 = 1.6 time = 420
* CHECK dout0_8 vdout0_8ck41 = 1.6 time = 420
* CHECK dout0_9 vdout0_9ck41 = 0 time = 420
* CHECK dout0_10 vdout0_10ck41 = 1.6 time = 420
* CHECK dout0_11 vdout0_11ck41 = 1.6 time = 420
* CHECK dout0_12 vdout0_12ck41 = 1.6 time = 420
* CHECK dout0_13 vdout0_13ck41 = 1.6 time = 420
* CHECK dout0_14 vdout0_14ck41 = 0 time = 420
* CHECK dout0_15 vdout0_15ck41 = 1.6 time = 420
* CHECK dout0_16 vdout0_16ck41 = 1.6 time = 420
* CHECK dout0_17 vdout0_17ck41 = 0 time = 420
* CHECK dout0_18 vdout0_18ck41 = 0 time = 420
* CHECK dout0_19 vdout0_19ck41 = 0 time = 420
* CHECK dout0_20 vdout0_20ck41 = 1.6 time = 420
* CHECK dout0_21 vdout0_21ck41 = 0 time = 420
* CHECK dout0_22 vdout0_22ck41 = 0 time = 420
* CHECK dout0_23 vdout0_23ck41 = 1.6 time = 420
* CHECK dout0_24 vdout0_24ck41 = 0 time = 420
* CHECK dout0_25 vdout0_25ck41 = 1.6 time = 420
* CHECK dout0_26 vdout0_26ck41 = 1.6 time = 420
* CHECK dout0_27 vdout0_27ck41 = 1.6 time = 420
* CHECK dout0_28 vdout0_28ck41 = 1.6 time = 420
* CHECK dout0_29 vdout0_29ck41 = 1.6 time = 420
* CHECK dout0_30 vdout0_30ck41 = 0 time = 420
* CHECK dout0_31 vdout0_31ck41 = 1.6 time = 420
* CHECK dout0_32 vdout0_32ck41 = 0 time = 420
* CHECK dout0_0 vdout0_0ck42 = 0 time = 430
* CHECK dout0_1 vdout0_1ck42 = 0 time = 430
* CHECK dout0_2 vdout0_2ck42 = 0 time = 430
* CHECK dout0_3 vdout0_3ck42 = 1.6 time = 430
* CHECK dout0_4 vdout0_4ck42 = 0 time = 430
* CHECK dout0_5 vdout0_5ck42 = 0 time = 430
* CHECK dout0_6 vdout0_6ck42 = 1.6 time = 430
* CHECK dout0_7 vdout0_7ck42 = 0 time = 430
* CHECK dout0_8 vdout0_8ck42 = 1.6 time = 430
* CHECK dout0_9 vdout0_9ck42 = 1.6 time = 430
* CHECK dout0_10 vdout0_10ck42 = 0 time = 430
* CHECK dout0_11 vdout0_11ck42 = 0 time = 430
* CHECK dout0_12 vdout0_12ck42 = 1.6 time = 430
* CHECK dout0_13 vdout0_13ck42 = 1.6 time = 430
* CHECK dout0_14 vdout0_14ck42 = 1.6 time = 430
* CHECK dout0_15 vdout0_15ck42 = 1.6 time = 430
* CHECK dout0_16 vdout0_16ck42 = 0 time = 430
* CHECK dout0_17 vdout0_17ck42 = 1.6 time = 430
* CHECK dout0_18 vdout0_18ck42 = 1.6 time = 430
* CHECK dout0_19 vdout0_19ck42 = 1.6 time = 430
* CHECK dout0_20 vdout0_20ck42 = 0 time = 430
* CHECK dout0_21 vdout0_21ck42 = 0 time = 430
* CHECK dout0_22 vdout0_22ck42 = 1.6 time = 430
* CHECK dout0_23 vdout0_23ck42 = 0 time = 430
* CHECK dout0_24 vdout0_24ck42 = 1.6 time = 430
* CHECK dout0_25 vdout0_25ck42 = 1.6 time = 430
* CHECK dout0_26 vdout0_26ck42 = 0 time = 430
* CHECK dout0_27 vdout0_27ck42 = 0 time = 430
* CHECK dout0_28 vdout0_28ck42 = 0 time = 430
* CHECK dout0_29 vdout0_29ck42 = 1.6 time = 430
* CHECK dout0_30 vdout0_30ck42 = 1.6 time = 430
* CHECK dout0_31 vdout0_31ck42 = 0 time = 430
* CHECK dout0_32 vdout0_32ck42 = 0 time = 430
* CHECK dout0_0 vdout0_0ck43 = 1.6 time = 440
* CHECK dout0_1 vdout0_1ck43 = 0 time = 440
* CHECK dout0_2 vdout0_2ck43 = 0 time = 440
* CHECK dout0_3 vdout0_3ck43 = 1.6 time = 440
* CHECK dout0_4 vdout0_4ck43 = 1.6 time = 440
* CHECK dout0_5 vdout0_5ck43 = 1.6 time = 440
* CHECK dout0_6 vdout0_6ck43 = 0 time = 440
* CHECK dout0_7 vdout0_7ck43 = 1.6 time = 440
* CHECK dout0_8 vdout0_8ck43 = 1.6 time = 440
* CHECK dout0_9 vdout0_9ck43 = 0 time = 440
* CHECK dout0_10 vdout0_10ck43 = 1.6 time = 440
* CHECK dout0_11 vdout0_11ck43 = 1.6 time = 440
* CHECK dout0_12 vdout0_12ck43 = 1.6 time = 440
* CHECK dout0_13 vdout0_13ck43 = 1.6 time = 440
* CHECK dout0_14 vdout0_14ck43 = 0 time = 440
* CHECK dout0_15 vdout0_15ck43 = 1.6 time = 440
* CHECK dout0_16 vdout0_16ck43 = 1.6 time = 440
* CHECK dout0_17 vdout0_17ck43 = 0 time = 440
* CHECK dout0_18 vdout0_18ck43 = 0 time = 440
* CHECK dout0_19 vdout0_19ck43 = 0 time = 440
* CHECK dout0_20 vdout0_20ck43 = 1.6 time = 440
* CHECK dout0_21 vdout0_21ck43 = 0 time = 440
* CHECK dout0_22 vdout0_22ck43 = 0 time = 440
* CHECK dout0_23 vdout0_23ck43 = 1.6 time = 440
* CHECK dout0_24 vdout0_24ck43 = 0 time = 440
* CHECK dout0_25 vdout0_25ck43 = 1.6 time = 440
* CHECK dout0_26 vdout0_26ck43 = 1.6 time = 440
* CHECK dout0_27 vdout0_27ck43 = 1.6 time = 440
* CHECK dout0_28 vdout0_28ck43 = 1.6 time = 440
* CHECK dout0_29 vdout0_29ck43 = 1.6 time = 440
* CHECK dout0_30 vdout0_30ck43 = 0 time = 440
* CHECK dout0_31 vdout0_31ck43 = 1.6 time = 440
* CHECK dout0_32 vdout0_32ck43 = 0 time = 440
* CHECK dout1_0 vdout1_0ck43 = 0 time = 440
* CHECK dout1_1 vdout1_1ck43 = 0 time = 440
* CHECK dout1_2 vdout1_2ck43 = 1.6 time = 440
* CHECK dout1_3 vdout1_3ck43 = 0 time = 440
* CHECK dout1_4 vdout1_4ck43 = 0 time = 440
* CHECK dout1_5 vdout1_5ck43 = 1.6 time = 440
* CHECK dout1_6 vdout1_6ck43 = 0 time = 440
* CHECK dout1_7 vdout1_7ck43 = 1.6 time = 440
* CHECK dout1_8 vdout1_8ck43 = 0 time = 440
* CHECK dout1_9 vdout1_9ck43 = 1.6 time = 440
* CHECK dout1_10 vdout1_10ck43 = 0 time = 440
* CHECK dout1_11 vdout1_11ck43 = 0 time = 440
* CHECK dout1_12 vdout1_12ck43 = 1.6 time = 440
* CHECK dout1_13 vdout1_13ck43 = 0 time = 440
* CHECK dout1_14 vdout1_14ck43 = 0 time = 440
* CHECK dout1_15 vdout1_15ck43 = 0 time = 440
* CHECK dout1_16 vdout1_16ck43 = 1.6 time = 440
* CHECK dout1_17 vdout1_17ck43 = 1.6 time = 440
* CHECK dout1_18 vdout1_18ck43 = 1.6 time = 440
* CHECK dout1_19 vdout1_19ck43 = 1.6 time = 440
* CHECK dout1_20 vdout1_20ck43 = 0 time = 440
* CHECK dout1_21 vdout1_21ck43 = 0 time = 440
* CHECK dout1_22 vdout1_22ck43 = 0 time = 440
* CHECK dout1_23 vdout1_23ck43 = 1.6 time = 440
* CHECK dout1_24 vdout1_24ck43 = 0 time = 440
* CHECK dout1_25 vdout1_25ck43 = 0 time = 440
* CHECK dout1_26 vdout1_26ck43 = 1.6 time = 440
* CHECK dout1_27 vdout1_27ck43 = 0 time = 440
* CHECK dout1_28 vdout1_28ck43 = 1.6 time = 440
* CHECK dout1_29 vdout1_29ck43 = 0 time = 440
* CHECK dout1_30 vdout1_30ck43 = 0 time = 440
* CHECK dout1_31 vdout1_31ck43 = 0 time = 440
* CHECK dout1_32 vdout1_32ck43 = 0 time = 440
* CHECK dout0_0 vdout0_0ck44 = 0 time = 450
* CHECK dout0_1 vdout0_1ck44 = 0 time = 450
* CHECK dout0_2 vdout0_2ck44 = 0 time = 450
* CHECK dout0_3 vdout0_3ck44 = 1.6 time = 450
* CHECK dout0_4 vdout0_4ck44 = 0 time = 450
* CHECK dout0_5 vdout0_5ck44 = 0 time = 450
* CHECK dout0_6 vdout0_6ck44 = 1.6 time = 450
* CHECK dout0_7 vdout0_7ck44 = 0 time = 450
* CHECK dout0_8 vdout0_8ck44 = 1.6 time = 450
* CHECK dout0_9 vdout0_9ck44 = 1.6 time = 450
* CHECK dout0_10 vdout0_10ck44 = 0 time = 450
* CHECK dout0_11 vdout0_11ck44 = 0 time = 450
* CHECK dout0_12 vdout0_12ck44 = 1.6 time = 450
* CHECK dout0_13 vdout0_13ck44 = 1.6 time = 450
* CHECK dout0_14 vdout0_14ck44 = 1.6 time = 450
* CHECK dout0_15 vdout0_15ck44 = 1.6 time = 450
* CHECK dout0_16 vdout0_16ck44 = 0 time = 450
* CHECK dout0_17 vdout0_17ck44 = 1.6 time = 450
* CHECK dout0_18 vdout0_18ck44 = 1.6 time = 450
* CHECK dout0_19 vdout0_19ck44 = 1.6 time = 450
* CHECK dout0_20 vdout0_20ck44 = 0 time = 450
* CHECK dout0_21 vdout0_21ck44 = 0 time = 450
* CHECK dout0_22 vdout0_22ck44 = 1.6 time = 450
* CHECK dout0_23 vdout0_23ck44 = 0 time = 450
* CHECK dout0_24 vdout0_24ck44 = 1.6 time = 450
* CHECK dout0_25 vdout0_25ck44 = 1.6 time = 450
* CHECK dout0_26 vdout0_26ck44 = 0 time = 450
* CHECK dout0_27 vdout0_27ck44 = 0 time = 450
* CHECK dout0_28 vdout0_28ck44 = 0 time = 450
* CHECK dout0_29 vdout0_29ck44 = 1.6 time = 450
* CHECK dout0_30 vdout0_30ck44 = 1.6 time = 450
* CHECK dout0_31 vdout0_31ck44 = 0 time = 450
* CHECK dout0_32 vdout0_32ck44 = 0 time = 450
* CHECK dout0_0 vdout0_0ck47 = 0 time = 480
* CHECK dout0_1 vdout0_1ck47 = 0 time = 480
* CHECK dout0_2 vdout0_2ck47 = 1.6 time = 480
* CHECK dout0_3 vdout0_3ck47 = 0 time = 480
* CHECK dout0_4 vdout0_4ck47 = 0 time = 480
* CHECK dout0_5 vdout0_5ck47 = 1.6 time = 480
* CHECK dout0_6 vdout0_6ck47 = 0 time = 480
* CHECK dout0_7 vdout0_7ck47 = 1.6 time = 480
* CHECK dout0_8 vdout0_8ck47 = 0 time = 480
* CHECK dout0_9 vdout0_9ck47 = 1.6 time = 480
* CHECK dout0_10 vdout0_10ck47 = 0 time = 480
* CHECK dout0_11 vdout0_11ck47 = 0 time = 480
* CHECK dout0_12 vdout0_12ck47 = 1.6 time = 480
* CHECK dout0_13 vdout0_13ck47 = 0 time = 480
* CHECK dout0_14 vdout0_14ck47 = 0 time = 480
* CHECK dout0_15 vdout0_15ck47 = 0 time = 480
* CHECK dout0_16 vdout0_16ck47 = 1.6 time = 480
* CHECK dout0_17 vdout0_17ck47 = 1.6 time = 480
* CHECK dout0_18 vdout0_18ck47 = 1.6 time = 480
* CHECK dout0_19 vdout0_19ck47 = 1.6 time = 480
* CHECK dout0_20 vdout0_20ck47 = 0 time = 480
* CHECK dout0_21 vdout0_21ck47 = 0 time = 480
* CHECK dout0_22 vdout0_22ck47 = 0 time = 480
* CHECK dout0_23 vdout0_23ck47 = 1.6 time = 480
* CHECK dout0_24 vdout0_24ck47 = 0 time = 480
* CHECK dout0_25 vdout0_25ck47 = 0 time = 480
* CHECK dout0_26 vdout0_26ck47 = 1.6 time = 480
* CHECK dout0_27 vdout0_27ck47 = 0 time = 480
* CHECK dout0_28 vdout0_28ck47 = 1.6 time = 480
* CHECK dout0_29 vdout0_29ck47 = 0 time = 480
* CHECK dout0_30 vdout0_30ck47 = 0 time = 480
* CHECK dout0_31 vdout0_31ck47 = 0 time = 480
* CHECK dout0_32 vdout0_32ck47 = 0 time = 480
* CHECK dout0_0 vdout0_0ck50 = 1.6 time = 510
* CHECK dout0_1 vdout0_1ck50 = 0 time = 510
* CHECK dout0_2 vdout0_2ck50 = 0 time = 510
* CHECK dout0_3 vdout0_3ck50 = 1.6 time = 510
* CHECK dout0_4 vdout0_4ck50 = 1.6 time = 510
* CHECK dout0_5 vdout0_5ck50 = 1.6 time = 510
* CHECK dout0_6 vdout0_6ck50 = 0 time = 510
* CHECK dout0_7 vdout0_7ck50 = 1.6 time = 510
* CHECK dout0_8 vdout0_8ck50 = 1.6 time = 510
* CHECK dout0_9 vdout0_9ck50 = 0 time = 510
* CHECK dout0_10 vdout0_10ck50 = 1.6 time = 510
* CHECK dout0_11 vdout0_11ck50 = 1.6 time = 510
* CHECK dout0_12 vdout0_12ck50 = 1.6 time = 510
* CHECK dout0_13 vdout0_13ck50 = 1.6 time = 510
* CHECK dout0_14 vdout0_14ck50 = 0 time = 510
* CHECK dout0_15 vdout0_15ck50 = 1.6 time = 510
* CHECK dout0_16 vdout0_16ck50 = 1.6 time = 510
* CHECK dout0_17 vdout0_17ck50 = 0 time = 510
* CHECK dout0_18 vdout0_18ck50 = 0 time = 510
* CHECK dout0_19 vdout0_19ck50 = 0 time = 510
* CHECK dout0_20 vdout0_20ck50 = 1.6 time = 510
* CHECK dout0_21 vdout0_21ck50 = 0 time = 510
* CHECK dout0_22 vdout0_22ck50 = 0 time = 510
* CHECK dout0_23 vdout0_23ck50 = 1.6 time = 510
* CHECK dout0_24 vdout0_24ck50 = 0 time = 510
* CHECK dout0_25 vdout0_25ck50 = 1.6 time = 510
* CHECK dout0_26 vdout0_26ck50 = 1.6 time = 510
* CHECK dout0_27 vdout0_27ck50 = 1.6 time = 510
* CHECK dout0_28 vdout0_28ck50 = 1.6 time = 510
* CHECK dout0_29 vdout0_29ck50 = 1.6 time = 510
* CHECK dout0_30 vdout0_30ck50 = 0 time = 510
* CHECK dout0_31 vdout0_31ck50 = 1.6 time = 510
* CHECK dout0_32 vdout0_32ck50 = 0 time = 510
* CHECK dout1_0 vdout1_0ck50 = 1.6 time = 510
* CHECK dout1_1 vdout1_1ck50 = 0 time = 510
* CHECK dout1_2 vdout1_2ck50 = 1.6 time = 510
* CHECK dout1_3 vdout1_3ck50 = 1.6 time = 510
* CHECK dout1_4 vdout1_4ck50 = 0 time = 510
* CHECK dout1_5 vdout1_5ck50 = 0 time = 510
* CHECK dout1_6 vdout1_6ck50 = 0 time = 510
* CHECK dout1_7 vdout1_7ck50 = 0 time = 510
* CHECK dout1_8 vdout1_8ck50 = 1.6 time = 510
* CHECK dout1_9 vdout1_9ck50 = 0 time = 510
* CHECK dout1_10 vdout1_10ck50 = 1.6 time = 510
* CHECK dout1_11 vdout1_11ck50 = 0 time = 510
* CHECK dout1_12 vdout1_12ck50 = 0 time = 510
* CHECK dout1_13 vdout1_13ck50 = 1.6 time = 510
* CHECK dout1_14 vdout1_14ck50 = 0 time = 510
* CHECK dout1_15 vdout1_15ck50 = 1.6 time = 510
* CHECK dout1_16 vdout1_16ck50 = 1.6 time = 510
* CHECK dout1_17 vdout1_17ck50 = 1.6 time = 510
* CHECK dout1_18 vdout1_18ck50 = 1.6 time = 510
* CHECK dout1_19 vdout1_19ck50 = 0 time = 510
* CHECK dout1_20 vdout1_20ck50 = 0 time = 510
* CHECK dout1_21 vdout1_21ck50 = 0 time = 510
* CHECK dout1_22 vdout1_22ck50 = 1.6 time = 510
* CHECK dout1_23 vdout1_23ck50 = 0 time = 510
* CHECK dout1_24 vdout1_24ck50 = 0 time = 510
* CHECK dout1_25 vdout1_25ck50 = 0 time = 510
* CHECK dout1_26 vdout1_26ck50 = 1.6 time = 510
* CHECK dout1_27 vdout1_27ck50 = 1.6 time = 510
* CHECK dout1_28 vdout1_28ck50 = 1.6 time = 510
* CHECK dout1_29 vdout1_29ck50 = 1.6 time = 510
* CHECK dout1_30 vdout1_30ck50 = 1.6 time = 510
* CHECK dout1_31 vdout1_31ck50 = 0 time = 510
* CHECK dout1_32 vdout1_32ck50 = 0 time = 510
* CHECK dout0_0 vdout0_0ck51 = 0 time = 520
* CHECK dout0_1 vdout0_1ck51 = 0 time = 520
* CHECK dout0_2 vdout0_2ck51 = 1.6 time = 520
* CHECK dout0_3 vdout0_3ck51 = 0 time = 520
* CHECK dout0_4 vdout0_4ck51 = 0 time = 520
* CHECK dout0_5 vdout0_5ck51 = 1.6 time = 520
* CHECK dout0_6 vdout0_6ck51 = 0 time = 520
* CHECK dout0_7 vdout0_7ck51 = 1.6 time = 520
* CHECK dout0_8 vdout0_8ck51 = 0 time = 520
* CHECK dout0_9 vdout0_9ck51 = 1.6 time = 520
* CHECK dout0_10 vdout0_10ck51 = 0 time = 520
* CHECK dout0_11 vdout0_11ck51 = 0 time = 520
* CHECK dout0_12 vdout0_12ck51 = 1.6 time = 520
* CHECK dout0_13 vdout0_13ck51 = 0 time = 520
* CHECK dout0_14 vdout0_14ck51 = 0 time = 520
* CHECK dout0_15 vdout0_15ck51 = 0 time = 520
* CHECK dout0_16 vdout0_16ck51 = 1.6 time = 520
* CHECK dout0_17 vdout0_17ck51 = 1.6 time = 520
* CHECK dout0_18 vdout0_18ck51 = 1.6 time = 520
* CHECK dout0_19 vdout0_19ck51 = 1.6 time = 520
* CHECK dout0_20 vdout0_20ck51 = 0 time = 520
* CHECK dout0_21 vdout0_21ck51 = 0 time = 520
* CHECK dout0_22 vdout0_22ck51 = 0 time = 520
* CHECK dout0_23 vdout0_23ck51 = 1.6 time = 520
* CHECK dout0_24 vdout0_24ck51 = 0 time = 520
* CHECK dout0_25 vdout0_25ck51 = 0 time = 520
* CHECK dout0_26 vdout0_26ck51 = 1.6 time = 520
* CHECK dout0_27 vdout0_27ck51 = 0 time = 520
* CHECK dout0_28 vdout0_28ck51 = 1.6 time = 520
* CHECK dout0_29 vdout0_29ck51 = 0 time = 520
* CHECK dout0_30 vdout0_30ck51 = 0 time = 520
* CHECK dout0_31 vdout0_31ck51 = 0 time = 520
* CHECK dout0_32 vdout0_32ck51 = 0 time = 520
* CHECK dout1_0 vdout1_0ck52 = 0 time = 530
* CHECK dout1_1 vdout1_1ck52 = 0 time = 530
* CHECK dout1_2 vdout1_2ck52 = 1.6 time = 530
* CHECK dout1_3 vdout1_3ck52 = 0 time = 530
* CHECK dout1_4 vdout1_4ck52 = 0 time = 530
* CHECK dout1_5 vdout1_5ck52 = 1.6 time = 530
* CHECK dout1_6 vdout1_6ck52 = 0 time = 530
* CHECK dout1_7 vdout1_7ck52 = 1.6 time = 530
* CHECK dout1_8 vdout1_8ck52 = 0 time = 530
* CHECK dout1_9 vdout1_9ck52 = 1.6 time = 530
* CHECK dout1_10 vdout1_10ck52 = 0 time = 530
* CHECK dout1_11 vdout1_11ck52 = 0 time = 530
* CHECK dout1_12 vdout1_12ck52 = 1.6 time = 530
* CHECK dout1_13 vdout1_13ck52 = 0 time = 530
* CHECK dout1_14 vdout1_14ck52 = 0 time = 530
* CHECK dout1_15 vdout1_15ck52 = 0 time = 530
* CHECK dout1_16 vdout1_16ck52 = 1.6 time = 530
* CHECK dout1_17 vdout1_17ck52 = 1.6 time = 530
* CHECK dout1_18 vdout1_18ck52 = 1.6 time = 530
* CHECK dout1_19 vdout1_19ck52 = 1.6 time = 530
* CHECK dout1_20 vdout1_20ck52 = 0 time = 530
* CHECK dout1_21 vdout1_21ck52 = 0 time = 530
* CHECK dout1_22 vdout1_22ck52 = 0 time = 530
* CHECK dout1_23 vdout1_23ck52 = 1.6 time = 530
* CHECK dout1_24 vdout1_24ck52 = 0 time = 530
* CHECK dout1_25 vdout1_25ck52 = 0 time = 530
* CHECK dout1_26 vdout1_26ck52 = 1.6 time = 530
* CHECK dout1_27 vdout1_27ck52 = 0 time = 530
* CHECK dout1_28 vdout1_28ck52 = 1.6 time = 530
* CHECK dout1_29 vdout1_29ck52 = 0 time = 530
* CHECK dout1_30 vdout1_30ck52 = 0 time = 530
* CHECK dout1_31 vdout1_31ck52 = 0 time = 530
* CHECK dout1_32 vdout1_32ck52 = 0 time = 530
* CHECK dout0_0 vdout0_0ck54 = 1.6 time = 550
* CHECK dout0_1 vdout0_1ck54 = 0 time = 550
* CHECK dout0_2 vdout0_2ck54 = 0 time = 550
* CHECK dout0_3 vdout0_3ck54 = 0 time = 550
* CHECK dout0_4 vdout0_4ck54 = 0 time = 550
* CHECK dout0_5 vdout0_5ck54 = 0 time = 550
* CHECK dout0_6 vdout0_6ck54 = 1.6 time = 550
* CHECK dout0_7 vdout0_7ck54 = 1.6 time = 550
* CHECK dout0_8 vdout0_8ck54 = 1.6 time = 550
* CHECK dout0_9 vdout0_9ck54 = 1.6 time = 550
* CHECK dout0_10 vdout0_10ck54 = 1.6 time = 550
* CHECK dout0_11 vdout0_11ck54 = 1.6 time = 550
* CHECK dout0_12 vdout0_12ck54 = 1.6 time = 550
* CHECK dout0_13 vdout0_13ck54 = 0 time = 550
* CHECK dout0_14 vdout0_14ck54 = 0 time = 550
* CHECK dout0_15 vdout0_15ck54 = 1.6 time = 550
* CHECK dout0_16 vdout0_16ck54 = 0 time = 550
* CHECK dout0_17 vdout0_17ck54 = 0 time = 550
* CHECK dout0_18 vdout0_18ck54 = 0 time = 550
* CHECK dout0_19 vdout0_19ck54 = 0 time = 550
* CHECK dout0_20 vdout0_20ck54 = 1.6 time = 550
* CHECK dout0_21 vdout0_21ck54 = 1.6 time = 550
* CHECK dout0_22 vdout0_22ck54 = 0 time = 550
* CHECK dout0_23 vdout0_23ck54 = 1.6 time = 550
* CHECK dout0_24 vdout0_24ck54 = 1.6 time = 550
* CHECK dout0_25 vdout0_25ck54 = 1.6 time = 550
* CHECK dout0_26 vdout0_26ck54 = 0 time = 550
* CHECK dout0_27 vdout0_27ck54 = 1.6 time = 550
* CHECK dout0_28 vdout0_28ck54 = 0 time = 550
* CHECK dout0_29 vdout0_29ck54 = 1.6 time = 550
* CHECK dout0_30 vdout0_30ck54 = 0 time = 550
* CHECK dout0_31 vdout0_31ck54 = 0 time = 550
* CHECK dout0_32 vdout0_32ck54 = 0 time = 550
* CHECK dout0_0 vdout0_0ck55 = 0 time = 560
* CHECK dout0_1 vdout0_1ck55 = 0 time = 560
* CHECK dout0_2 vdout0_2ck55 = 1.6 time = 560
* CHECK dout0_3 vdout0_3ck55 = 0 time = 560
* CHECK dout0_4 vdout0_4ck55 = 0 time = 560
* CHECK dout0_5 vdout0_5ck55 = 1.6 time = 560
* CHECK dout0_6 vdout0_6ck55 = 0 time = 560
* CHECK dout0_7 vdout0_7ck55 = 1.6 time = 560
* CHECK dout0_8 vdout0_8ck55 = 0 time = 560
* CHECK dout0_9 vdout0_9ck55 = 1.6 time = 560
* CHECK dout0_10 vdout0_10ck55 = 0 time = 560
* CHECK dout0_11 vdout0_11ck55 = 0 time = 560
* CHECK dout0_12 vdout0_12ck55 = 1.6 time = 560
* CHECK dout0_13 vdout0_13ck55 = 0 time = 560
* CHECK dout0_14 vdout0_14ck55 = 0 time = 560
* CHECK dout0_15 vdout0_15ck55 = 0 time = 560
* CHECK dout0_16 vdout0_16ck55 = 1.6 time = 560
* CHECK dout0_17 vdout0_17ck55 = 1.6 time = 560
* CHECK dout0_18 vdout0_18ck55 = 1.6 time = 560
* CHECK dout0_19 vdout0_19ck55 = 1.6 time = 560
* CHECK dout0_20 vdout0_20ck55 = 0 time = 560
* CHECK dout0_21 vdout0_21ck55 = 0 time = 560
* CHECK dout0_22 vdout0_22ck55 = 0 time = 560
* CHECK dout0_23 vdout0_23ck55 = 1.6 time = 560
* CHECK dout0_24 vdout0_24ck55 = 0 time = 560
* CHECK dout0_25 vdout0_25ck55 = 0 time = 560
* CHECK dout0_26 vdout0_26ck55 = 1.6 time = 560
* CHECK dout0_27 vdout0_27ck55 = 0 time = 560
* CHECK dout0_28 vdout0_28ck55 = 1.6 time = 560
* CHECK dout0_29 vdout0_29ck55 = 0 time = 560
* CHECK dout0_30 vdout0_30ck55 = 0 time = 560
* CHECK dout0_31 vdout0_31ck55 = 0 time = 560
* CHECK dout0_32 vdout0_32ck55 = 0 time = 560
* CHECK dout0_0 vdout0_0ck56 = 1.6 time = 570
* CHECK dout0_1 vdout0_1ck56 = 0 time = 570
* CHECK dout0_2 vdout0_2ck56 = 0 time = 570
* CHECK dout0_3 vdout0_3ck56 = 0 time = 570
* CHECK dout0_4 vdout0_4ck56 = 0 time = 570
* CHECK dout0_5 vdout0_5ck56 = 0 time = 570
* CHECK dout0_6 vdout0_6ck56 = 1.6 time = 570
* CHECK dout0_7 vdout0_7ck56 = 1.6 time = 570
* CHECK dout0_8 vdout0_8ck56 = 1.6 time = 570
* CHECK dout0_9 vdout0_9ck56 = 1.6 time = 570
* CHECK dout0_10 vdout0_10ck56 = 1.6 time = 570
* CHECK dout0_11 vdout0_11ck56 = 1.6 time = 570
* CHECK dout0_12 vdout0_12ck56 = 1.6 time = 570
* CHECK dout0_13 vdout0_13ck56 = 0 time = 570
* CHECK dout0_14 vdout0_14ck56 = 0 time = 570
* CHECK dout0_15 vdout0_15ck56 = 1.6 time = 570
* CHECK dout0_16 vdout0_16ck56 = 0 time = 570
* CHECK dout0_17 vdout0_17ck56 = 0 time = 570
* CHECK dout0_18 vdout0_18ck56 = 0 time = 570
* CHECK dout0_19 vdout0_19ck56 = 0 time = 570
* CHECK dout0_20 vdout0_20ck56 = 1.6 time = 570
* CHECK dout0_21 vdout0_21ck56 = 1.6 time = 570
* CHECK dout0_22 vdout0_22ck56 = 0 time = 570
* CHECK dout0_23 vdout0_23ck56 = 1.6 time = 570
* CHECK dout0_24 vdout0_24ck56 = 1.6 time = 570
* CHECK dout0_25 vdout0_25ck56 = 1.6 time = 570
* CHECK dout0_26 vdout0_26ck56 = 0 time = 570
* CHECK dout0_27 vdout0_27ck56 = 1.6 time = 570
* CHECK dout0_28 vdout0_28ck56 = 0 time = 570
* CHECK dout0_29 vdout0_29ck56 = 1.6 time = 570
* CHECK dout0_30 vdout0_30ck56 = 0 time = 570
* CHECK dout0_31 vdout0_31ck56 = 0 time = 570
* CHECK dout0_32 vdout0_32ck56 = 0 time = 570
* CHECK dout0_0 vdout0_0ck57 = 1.6 time = 580
* CHECK dout0_1 vdout0_1ck57 = 0 time = 580
* CHECK dout0_2 vdout0_2ck57 = 1.6 time = 580
* CHECK dout0_3 vdout0_3ck57 = 1.6 time = 580
* CHECK dout0_4 vdout0_4ck57 = 0 time = 580
* CHECK dout0_5 vdout0_5ck57 = 0 time = 580
* CHECK dout0_6 vdout0_6ck57 = 0 time = 580
* CHECK dout0_7 vdout0_7ck57 = 0 time = 580
* CHECK dout0_8 vdout0_8ck57 = 1.6 time = 580
* CHECK dout0_9 vdout0_9ck57 = 0 time = 580
* CHECK dout0_10 vdout0_10ck57 = 1.6 time = 580
* CHECK dout0_11 vdout0_11ck57 = 0 time = 580
* CHECK dout0_12 vdout0_12ck57 = 0 time = 580
* CHECK dout0_13 vdout0_13ck57 = 1.6 time = 580
* CHECK dout0_14 vdout0_14ck57 = 0 time = 580
* CHECK dout0_15 vdout0_15ck57 = 1.6 time = 580
* CHECK dout0_16 vdout0_16ck57 = 1.6 time = 580
* CHECK dout0_17 vdout0_17ck57 = 1.6 time = 580
* CHECK dout0_18 vdout0_18ck57 = 1.6 time = 580
* CHECK dout0_19 vdout0_19ck57 = 0 time = 580
* CHECK dout0_20 vdout0_20ck57 = 0 time = 580
* CHECK dout0_21 vdout0_21ck57 = 0 time = 580
* CHECK dout0_22 vdout0_22ck57 = 1.6 time = 580
* CHECK dout0_23 vdout0_23ck57 = 0 time = 580
* CHECK dout0_24 vdout0_24ck57 = 0 time = 580
* CHECK dout0_25 vdout0_25ck57 = 0 time = 580
* CHECK dout0_26 vdout0_26ck57 = 1.6 time = 580
* CHECK dout0_27 vdout0_27ck57 = 1.6 time = 580
* CHECK dout0_28 vdout0_28ck57 = 1.6 time = 580
* CHECK dout0_29 vdout0_29ck57 = 1.6 time = 580
* CHECK dout0_30 vdout0_30ck57 = 1.6 time = 580
* CHECK dout0_31 vdout0_31ck57 = 0 time = 580
* CHECK dout0_32 vdout0_32ck57 = 0 time = 580
* CHECK dout1_0 vdout1_0ck58 = 1.6 time = 590
* CHECK dout1_1 vdout1_1ck58 = 0 time = 590
* CHECK dout1_2 vdout1_2ck58 = 0 time = 590
* CHECK dout1_3 vdout1_3ck58 = 0 time = 590
* CHECK dout1_4 vdout1_4ck58 = 0 time = 590
* CHECK dout1_5 vdout1_5ck58 = 0 time = 590
* CHECK dout1_6 vdout1_6ck58 = 1.6 time = 590
* CHECK dout1_7 vdout1_7ck58 = 1.6 time = 590
* CHECK dout1_8 vdout1_8ck58 = 1.6 time = 590
* CHECK dout1_9 vdout1_9ck58 = 1.6 time = 590
* CHECK dout1_10 vdout1_10ck58 = 1.6 time = 590
* CHECK dout1_11 vdout1_11ck58 = 1.6 time = 590
* CHECK dout1_12 vdout1_12ck58 = 1.6 time = 590
* CHECK dout1_13 vdout1_13ck58 = 0 time = 590
* CHECK dout1_14 vdout1_14ck58 = 0 time = 590
* CHECK dout1_15 vdout1_15ck58 = 1.6 time = 590
* CHECK dout1_16 vdout1_16ck58 = 0 time = 590
* CHECK dout1_17 vdout1_17ck58 = 0 time = 590
* CHECK dout1_18 vdout1_18ck58 = 0 time = 590
* CHECK dout1_19 vdout1_19ck58 = 0 time = 590
* CHECK dout1_20 vdout1_20ck58 = 1.6 time = 590
* CHECK dout1_21 vdout1_21ck58 = 1.6 time = 590
* CHECK dout1_22 vdout1_22ck58 = 0 time = 590
* CHECK dout1_23 vdout1_23ck58 = 1.6 time = 590
* CHECK dout1_24 vdout1_24ck58 = 1.6 time = 590
* CHECK dout1_25 vdout1_25ck58 = 1.6 time = 590
* CHECK dout1_26 vdout1_26ck58 = 0 time = 590
* CHECK dout1_27 vdout1_27ck58 = 1.6 time = 590
* CHECK dout1_28 vdout1_28ck58 = 0 time = 590
* CHECK dout1_29 vdout1_29ck58 = 1.6 time = 590
* CHECK dout1_30 vdout1_30ck58 = 0 time = 590
* CHECK dout1_31 vdout1_31ck58 = 0 time = 590
* CHECK dout1_32 vdout1_32ck58 = 0 time = 590
* CHECK dout0_0 vdout0_0ck59 = 1.6 time = 600
* CHECK dout0_1 vdout0_1ck59 = 0 time = 600
* CHECK dout0_2 vdout0_2ck59 = 1.6 time = 600
* CHECK dout0_3 vdout0_3ck59 = 1.6 time = 600
* CHECK dout0_4 vdout0_4ck59 = 0 time = 600
* CHECK dout0_5 vdout0_5ck59 = 0 time = 600
* CHECK dout0_6 vdout0_6ck59 = 0 time = 600
* CHECK dout0_7 vdout0_7ck59 = 0 time = 600
* CHECK dout0_8 vdout0_8ck59 = 1.6 time = 600
* CHECK dout0_9 vdout0_9ck59 = 0 time = 600
* CHECK dout0_10 vdout0_10ck59 = 1.6 time = 600
* CHECK dout0_11 vdout0_11ck59 = 0 time = 600
* CHECK dout0_12 vdout0_12ck59 = 0 time = 600
* CHECK dout0_13 vdout0_13ck59 = 1.6 time = 600
* CHECK dout0_14 vdout0_14ck59 = 0 time = 600
* CHECK dout0_15 vdout0_15ck59 = 1.6 time = 600
* CHECK dout0_16 vdout0_16ck59 = 1.6 time = 600
* CHECK dout0_17 vdout0_17ck59 = 1.6 time = 600
* CHECK dout0_18 vdout0_18ck59 = 1.6 time = 600
* CHECK dout0_19 vdout0_19ck59 = 0 time = 600
* CHECK dout0_20 vdout0_20ck59 = 0 time = 600
* CHECK dout0_21 vdout0_21ck59 = 0 time = 600
* CHECK dout0_22 vdout0_22ck59 = 1.6 time = 600
* CHECK dout0_23 vdout0_23ck59 = 0 time = 600
* CHECK dout0_24 vdout0_24ck59 = 0 time = 600
* CHECK dout0_25 vdout0_25ck59 = 0 time = 600
* CHECK dout0_26 vdout0_26ck59 = 1.6 time = 600
* CHECK dout0_27 vdout0_27ck59 = 1.6 time = 600
* CHECK dout0_28 vdout0_28ck59 = 1.6 time = 600
* CHECK dout0_29 vdout0_29ck59 = 1.6 time = 600
* CHECK dout0_30 vdout0_30ck59 = 1.6 time = 600
* CHECK dout0_31 vdout0_31ck59 = 0 time = 600
* CHECK dout0_32 vdout0_32ck59 = 0 time = 600
* CHECK dout1_0 vdout1_0ck59 = 1.6 time = 600
* CHECK dout1_1 vdout1_1ck59 = 1.6 time = 600
* CHECK dout1_2 vdout1_2ck59 = 1.6 time = 600
* CHECK dout1_3 vdout1_3ck59 = 1.6 time = 600
* CHECK dout1_4 vdout1_4ck59 = 1.6 time = 600
* CHECK dout1_5 vdout1_5ck59 = 0 time = 600
* CHECK dout1_6 vdout1_6ck59 = 0 time = 600
* CHECK dout1_7 vdout1_7ck59 = 1.6 time = 600
* CHECK dout1_8 vdout1_8ck59 = 1.6 time = 600
* CHECK dout1_9 vdout1_9ck59 = 0 time = 600
* CHECK dout1_10 vdout1_10ck59 = 0 time = 600
* CHECK dout1_11 vdout1_11ck59 = 1.6 time = 600
* CHECK dout1_12 vdout1_12ck59 = 0 time = 600
* CHECK dout1_13 vdout1_13ck59 = 0 time = 600
* CHECK dout1_14 vdout1_14ck59 = 0 time = 600
* CHECK dout1_15 vdout1_15ck59 = 0 time = 600
* CHECK dout1_16 vdout1_16ck59 = 1.6 time = 600
* CHECK dout1_17 vdout1_17ck59 = 1.6 time = 600
* CHECK dout1_18 vdout1_18ck59 = 1.6 time = 600
* CHECK dout1_19 vdout1_19ck59 = 0 time = 600
* CHECK dout1_20 vdout1_20ck59 = 0 time = 600
* CHECK dout1_21 vdout1_21ck59 = 0 time = 600
* CHECK dout1_22 vdout1_22ck59 = 1.6 time = 600
* CHECK dout1_23 vdout1_23ck59 = 0 time = 600
* CHECK dout1_24 vdout1_24ck59 = 1.6 time = 600
* CHECK dout1_25 vdout1_25ck59 = 1.6 time = 600
* CHECK dout1_26 vdout1_26ck59 = 1.6 time = 600
* CHECK dout1_27 vdout1_27ck59 = 0 time = 600
* CHECK dout1_28 vdout1_28ck59 = 1.6 time = 600
* CHECK dout1_29 vdout1_29ck59 = 0 time = 600
* CHECK dout1_30 vdout1_30ck59 = 1.6 time = 600
* CHECK dout1_31 vdout1_31ck59 = 1.6 time = 600
* CHECK dout1_32 vdout1_32ck59 = 0 time = 600
* CHECK dout0_0 vdout0_0ck60 = 1.6 time = 610
* CHECK dout0_1 vdout0_1ck60 = 0 time = 610
* CHECK dout0_2 vdout0_2ck60 = 1.6 time = 610
* CHECK dout0_3 vdout0_3ck60 = 1.6 time = 610
* CHECK dout0_4 vdout0_4ck60 = 0 time = 610
* CHECK dout0_5 vdout0_5ck60 = 0 time = 610
* CHECK dout0_6 vdout0_6ck60 = 0 time = 610
* CHECK dout0_7 vdout0_7ck60 = 0 time = 610
* CHECK dout0_8 vdout0_8ck60 = 1.6 time = 610
* CHECK dout0_9 vdout0_9ck60 = 0 time = 610
* CHECK dout0_10 vdout0_10ck60 = 1.6 time = 610
* CHECK dout0_11 vdout0_11ck60 = 0 time = 610
* CHECK dout0_12 vdout0_12ck60 = 0 time = 610
* CHECK dout0_13 vdout0_13ck60 = 1.6 time = 610
* CHECK dout0_14 vdout0_14ck60 = 0 time = 610
* CHECK dout0_15 vdout0_15ck60 = 1.6 time = 610
* CHECK dout0_16 vdout0_16ck60 = 1.6 time = 610
* CHECK dout0_17 vdout0_17ck60 = 1.6 time = 610
* CHECK dout0_18 vdout0_18ck60 = 1.6 time = 610
* CHECK dout0_19 vdout0_19ck60 = 0 time = 610
* CHECK dout0_20 vdout0_20ck60 = 0 time = 610
* CHECK dout0_21 vdout0_21ck60 = 0 time = 610
* CHECK dout0_22 vdout0_22ck60 = 1.6 time = 610
* CHECK dout0_23 vdout0_23ck60 = 0 time = 610
* CHECK dout0_24 vdout0_24ck60 = 0 time = 610
* CHECK dout0_25 vdout0_25ck60 = 0 time = 610
* CHECK dout0_26 vdout0_26ck60 = 1.6 time = 610
* CHECK dout0_27 vdout0_27ck60 = 1.6 time = 610
* CHECK dout0_28 vdout0_28ck60 = 1.6 time = 610
* CHECK dout0_29 vdout0_29ck60 = 1.6 time = 610
* CHECK dout0_30 vdout0_30ck60 = 1.6 time = 610
* CHECK dout0_31 vdout0_31ck60 = 0 time = 610
* CHECK dout0_32 vdout0_32ck60 = 0 time = 610
* CHECK dout0_0 vdout0_0ck61 = 1.6 time = 620
* CHECK dout0_1 vdout0_1ck61 = 1.6 time = 620
* CHECK dout0_2 vdout0_2ck61 = 1.6 time = 620
* CHECK dout0_3 vdout0_3ck61 = 1.6 time = 620
* CHECK dout0_4 vdout0_4ck61 = 1.6 time = 620
* CHECK dout0_5 vdout0_5ck61 = 0 time = 620
* CHECK dout0_6 vdout0_6ck61 = 0 time = 620
* CHECK dout0_7 vdout0_7ck61 = 1.6 time = 620
* CHECK dout0_8 vdout0_8ck61 = 1.6 time = 620
* CHECK dout0_9 vdout0_9ck61 = 0 time = 620
* CHECK dout0_10 vdout0_10ck61 = 0 time = 620
* CHECK dout0_11 vdout0_11ck61 = 1.6 time = 620
* CHECK dout0_12 vdout0_12ck61 = 0 time = 620
* CHECK dout0_13 vdout0_13ck61 = 0 time = 620
* CHECK dout0_14 vdout0_14ck61 = 0 time = 620
* CHECK dout0_15 vdout0_15ck61 = 0 time = 620
* CHECK dout0_16 vdout0_16ck61 = 1.6 time = 620
* CHECK dout0_17 vdout0_17ck61 = 1.6 time = 620
* CHECK dout0_18 vdout0_18ck61 = 1.6 time = 620
* CHECK dout0_19 vdout0_19ck61 = 0 time = 620
* CHECK dout0_20 vdout0_20ck61 = 0 time = 620
* CHECK dout0_21 vdout0_21ck61 = 0 time = 620
* CHECK dout0_22 vdout0_22ck61 = 1.6 time = 620
* CHECK dout0_23 vdout0_23ck61 = 0 time = 620
* CHECK dout0_24 vdout0_24ck61 = 1.6 time = 620
* CHECK dout0_25 vdout0_25ck61 = 1.6 time = 620
* CHECK dout0_26 vdout0_26ck61 = 1.6 time = 620
* CHECK dout0_27 vdout0_27ck61 = 0 time = 620
* CHECK dout0_28 vdout0_28ck61 = 1.6 time = 620
* CHECK dout0_29 vdout0_29ck61 = 0 time = 620
* CHECK dout0_30 vdout0_30ck61 = 1.6 time = 620
* CHECK dout0_31 vdout0_31ck61 = 1.6 time = 620
* CHECK dout0_32 vdout0_32ck61 = 0 time = 620
* CHECK dout1_0 vdout1_0ck61 = 0 time = 620
* CHECK dout1_1 vdout1_1ck61 = 0 time = 620
* CHECK dout1_2 vdout1_2ck61 = 1.6 time = 620
* CHECK dout1_3 vdout1_3ck61 = 0 time = 620
* CHECK dout1_4 vdout1_4ck61 = 0 time = 620
* CHECK dout1_5 vdout1_5ck61 = 1.6 time = 620
* CHECK dout1_6 vdout1_6ck61 = 0 time = 620
* CHECK dout1_7 vdout1_7ck61 = 1.6 time = 620
* CHECK dout1_8 vdout1_8ck61 = 0 time = 620
* CHECK dout1_9 vdout1_9ck61 = 1.6 time = 620
* CHECK dout1_10 vdout1_10ck61 = 0 time = 620
* CHECK dout1_11 vdout1_11ck61 = 0 time = 620
* CHECK dout1_12 vdout1_12ck61 = 1.6 time = 620
* CHECK dout1_13 vdout1_13ck61 = 0 time = 620
* CHECK dout1_14 vdout1_14ck61 = 0 time = 620
* CHECK dout1_15 vdout1_15ck61 = 0 time = 620
* CHECK dout1_16 vdout1_16ck61 = 1.6 time = 620
* CHECK dout1_17 vdout1_17ck61 = 1.6 time = 620
* CHECK dout1_18 vdout1_18ck61 = 1.6 time = 620
* CHECK dout1_19 vdout1_19ck61 = 1.6 time = 620
* CHECK dout1_20 vdout1_20ck61 = 0 time = 620
* CHECK dout1_21 vdout1_21ck61 = 0 time = 620
* CHECK dout1_22 vdout1_22ck61 = 0 time = 620
* CHECK dout1_23 vdout1_23ck61 = 1.6 time = 620
* CHECK dout1_24 vdout1_24ck61 = 0 time = 620
* CHECK dout1_25 vdout1_25ck61 = 0 time = 620
* CHECK dout1_26 vdout1_26ck61 = 1.6 time = 620
* CHECK dout1_27 vdout1_27ck61 = 0 time = 620
* CHECK dout1_28 vdout1_28ck61 = 1.6 time = 620
* CHECK dout1_29 vdout1_29ck61 = 0 time = 620
* CHECK dout1_30 vdout1_30ck61 = 0 time = 620
* CHECK dout1_31 vdout1_31ck61 = 0 time = 620
* CHECK dout1_32 vdout1_32ck61 = 0 time = 620
* CHECK dout0_0 vdout0_0ck63 = 0 time = 640
* CHECK dout0_1 vdout0_1ck63 = 1.6 time = 640
* CHECK dout0_2 vdout0_2ck63 = 1.6 time = 640
* CHECK dout0_3 vdout0_3ck63 = 1.6 time = 640
* CHECK dout0_4 vdout0_4ck63 = 0 time = 640
* CHECK dout0_5 vdout0_5ck63 = 0 time = 640
* CHECK dout0_6 vdout0_6ck63 = 0 time = 640
* CHECK dout0_7 vdout0_7ck63 = 1.6 time = 640
* CHECK dout0_8 vdout0_8ck63 = 0 time = 640
* CHECK dout0_9 vdout0_9ck63 = 1.6 time = 640
* CHECK dout0_10 vdout0_10ck63 = 1.6 time = 640
* CHECK dout0_11 vdout0_11ck63 = 1.6 time = 640
* CHECK dout0_12 vdout0_12ck63 = 0 time = 640
* CHECK dout0_13 vdout0_13ck63 = 1.6 time = 640
* CHECK dout0_14 vdout0_14ck63 = 1.6 time = 640
* CHECK dout0_15 vdout0_15ck63 = 0 time = 640
* CHECK dout0_16 vdout0_16ck63 = 0 time = 640
* CHECK dout0_17 vdout0_17ck63 = 0 time = 640
* CHECK dout0_18 vdout0_18ck63 = 1.6 time = 640
* CHECK dout0_19 vdout0_19ck63 = 1.6 time = 640
* CHECK dout0_20 vdout0_20ck63 = 0 time = 640
* CHECK dout0_21 vdout0_21ck63 = 1.6 time = 640
* CHECK dout0_22 vdout0_22ck63 = 1.6 time = 640
* CHECK dout0_23 vdout0_23ck63 = 1.6 time = 640
* CHECK dout0_24 vdout0_24ck63 = 1.6 time = 640
* CHECK dout0_25 vdout0_25ck63 = 1.6 time = 640
* CHECK dout0_26 vdout0_26ck63 = 1.6 time = 640
* CHECK dout0_27 vdout0_27ck63 = 0 time = 640
* CHECK dout0_28 vdout0_28ck63 = 0 time = 640
* CHECK dout0_29 vdout0_29ck63 = 1.6 time = 640
* CHECK dout0_30 vdout0_30ck63 = 0 time = 640
* CHECK dout0_31 vdout0_31ck63 = 0 time = 640
* CHECK dout0_32 vdout0_32ck63 = 0 time = 640
* CHECK dout1_0 vdout1_0ck65 = 1.6 time = 660
* CHECK dout1_1 vdout1_1ck65 = 0 time = 660
* CHECK dout1_2 vdout1_2ck65 = 0 time = 660
* CHECK dout1_3 vdout1_3ck65 = 0 time = 660
* CHECK dout1_4 vdout1_4ck65 = 0 time = 660
* CHECK dout1_5 vdout1_5ck65 = 0 time = 660
* CHECK dout1_6 vdout1_6ck65 = 1.6 time = 660
* CHECK dout1_7 vdout1_7ck65 = 1.6 time = 660
* CHECK dout1_8 vdout1_8ck65 = 1.6 time = 660
* CHECK dout1_9 vdout1_9ck65 = 1.6 time = 660
* CHECK dout1_10 vdout1_10ck65 = 1.6 time = 660
* CHECK dout1_11 vdout1_11ck65 = 1.6 time = 660
* CHECK dout1_12 vdout1_12ck65 = 1.6 time = 660
* CHECK dout1_13 vdout1_13ck65 = 0 time = 660
* CHECK dout1_14 vdout1_14ck65 = 0 time = 660
* CHECK dout1_15 vdout1_15ck65 = 1.6 time = 660
* CHECK dout1_16 vdout1_16ck65 = 0 time = 660
* CHECK dout1_17 vdout1_17ck65 = 0 time = 660
* CHECK dout1_18 vdout1_18ck65 = 0 time = 660
* CHECK dout1_19 vdout1_19ck65 = 0 time = 660
* CHECK dout1_20 vdout1_20ck65 = 1.6 time = 660
* CHECK dout1_21 vdout1_21ck65 = 1.6 time = 660
* CHECK dout1_22 vdout1_22ck65 = 0 time = 660
* CHECK dout1_23 vdout1_23ck65 = 1.6 time = 660
* CHECK dout1_24 vdout1_24ck65 = 1.6 time = 660
* CHECK dout1_25 vdout1_25ck65 = 1.6 time = 660
* CHECK dout1_26 vdout1_26ck65 = 0 time = 660
* CHECK dout1_27 vdout1_27ck65 = 1.6 time = 660
* CHECK dout1_28 vdout1_28ck65 = 0 time = 660
* CHECK dout1_29 vdout1_29ck65 = 1.6 time = 660
* CHECK dout1_30 vdout1_30ck65 = 0 time = 660
* CHECK dout1_31 vdout1_31ck65 = 0 time = 660
* CHECK dout1_32 vdout1_32ck65 = 0 time = 660
* CHECK dout0_0 vdout0_0ck66 = 1.6 time = 670
* CHECK dout0_1 vdout0_1ck66 = 0 time = 670
* CHECK dout0_2 vdout0_2ck66 = 0 time = 670
* CHECK dout0_3 vdout0_3ck66 = 0 time = 670
* CHECK dout0_4 vdout0_4ck66 = 0 time = 670
* CHECK dout0_5 vdout0_5ck66 = 0 time = 670
* CHECK dout0_6 vdout0_6ck66 = 1.6 time = 670
* CHECK dout0_7 vdout0_7ck66 = 1.6 time = 670
* CHECK dout0_8 vdout0_8ck66 = 1.6 time = 670
* CHECK dout0_9 vdout0_9ck66 = 1.6 time = 670
* CHECK dout0_10 vdout0_10ck66 = 1.6 time = 670
* CHECK dout0_11 vdout0_11ck66 = 1.6 time = 670
* CHECK dout0_12 vdout0_12ck66 = 1.6 time = 670
* CHECK dout0_13 vdout0_13ck66 = 0 time = 670
* CHECK dout0_14 vdout0_14ck66 = 0 time = 670
* CHECK dout0_15 vdout0_15ck66 = 1.6 time = 670
* CHECK dout0_16 vdout0_16ck66 = 0 time = 670
* CHECK dout0_17 vdout0_17ck66 = 0 time = 670
* CHECK dout0_18 vdout0_18ck66 = 0 time = 670
* CHECK dout0_19 vdout0_19ck66 = 0 time = 670
* CHECK dout0_20 vdout0_20ck66 = 1.6 time = 670
* CHECK dout0_21 vdout0_21ck66 = 1.6 time = 670
* CHECK dout0_22 vdout0_22ck66 = 0 time = 670
* CHECK dout0_23 vdout0_23ck66 = 1.6 time = 670
* CHECK dout0_24 vdout0_24ck66 = 1.6 time = 670
* CHECK dout0_25 vdout0_25ck66 = 1.6 time = 670
* CHECK dout0_26 vdout0_26ck66 = 0 time = 670
* CHECK dout0_27 vdout0_27ck66 = 1.6 time = 670
* CHECK dout0_28 vdout0_28ck66 = 0 time = 670
* CHECK dout0_29 vdout0_29ck66 = 1.6 time = 670
* CHECK dout0_30 vdout0_30ck66 = 0 time = 670
* CHECK dout0_31 vdout0_31ck66 = 0 time = 670
* CHECK dout0_32 vdout0_32ck66 = 0 time = 670
* CHECK dout1_0 vdout1_0ck66 = 1.6 time = 670
* CHECK dout1_1 vdout1_1ck66 = 0 time = 670
* CHECK dout1_2 vdout1_2ck66 = 0 time = 670
* CHECK dout1_3 vdout1_3ck66 = 0 time = 670
* CHECK dout1_4 vdout1_4ck66 = 0 time = 670
* CHECK dout1_5 vdout1_5ck66 = 0 time = 670
* CHECK dout1_6 vdout1_6ck66 = 1.6 time = 670
* CHECK dout1_7 vdout1_7ck66 = 1.6 time = 670
* CHECK dout1_8 vdout1_8ck66 = 1.6 time = 670
* CHECK dout1_9 vdout1_9ck66 = 1.6 time = 670
* CHECK dout1_10 vdout1_10ck66 = 1.6 time = 670
* CHECK dout1_11 vdout1_11ck66 = 1.6 time = 670
* CHECK dout1_12 vdout1_12ck66 = 1.6 time = 670
* CHECK dout1_13 vdout1_13ck66 = 0 time = 670
* CHECK dout1_14 vdout1_14ck66 = 0 time = 670
* CHECK dout1_15 vdout1_15ck66 = 1.6 time = 670
* CHECK dout1_16 vdout1_16ck66 = 0 time = 670
* CHECK dout1_17 vdout1_17ck66 = 0 time = 670
* CHECK dout1_18 vdout1_18ck66 = 0 time = 670
* CHECK dout1_19 vdout1_19ck66 = 0 time = 670
* CHECK dout1_20 vdout1_20ck66 = 1.6 time = 670
* CHECK dout1_21 vdout1_21ck66 = 1.6 time = 670
* CHECK dout1_22 vdout1_22ck66 = 0 time = 670
* CHECK dout1_23 vdout1_23ck66 = 1.6 time = 670
* CHECK dout1_24 vdout1_24ck66 = 1.6 time = 670
* CHECK dout1_25 vdout1_25ck66 = 1.6 time = 670
* CHECK dout1_26 vdout1_26ck66 = 0 time = 670
* CHECK dout1_27 vdout1_27ck66 = 1.6 time = 670
* CHECK dout1_28 vdout1_28ck66 = 0 time = 670
* CHECK dout1_29 vdout1_29ck66 = 1.6 time = 670
* CHECK dout1_30 vdout1_30ck66 = 0 time = 670
* CHECK dout1_31 vdout1_31ck66 = 0 time = 670
* CHECK dout1_32 vdout1_32ck66 = 0 time = 670
* CHECK dout0_0 vdout0_0ck67 = 1.6 time = 680
* CHECK dout0_1 vdout0_1ck67 = 0 time = 680
* CHECK dout0_2 vdout0_2ck67 = 0 time = 680
* CHECK dout0_3 vdout0_3ck67 = 0 time = 680
* CHECK dout0_4 vdout0_4ck67 = 0 time = 680
* CHECK dout0_5 vdout0_5ck67 = 0 time = 680
* CHECK dout0_6 vdout0_6ck67 = 1.6 time = 680
* CHECK dout0_7 vdout0_7ck67 = 1.6 time = 680
* CHECK dout0_8 vdout0_8ck67 = 1.6 time = 680
* CHECK dout0_9 vdout0_9ck67 = 1.6 time = 680
* CHECK dout0_10 vdout0_10ck67 = 1.6 time = 680
* CHECK dout0_11 vdout0_11ck67 = 1.6 time = 680
* CHECK dout0_12 vdout0_12ck67 = 1.6 time = 680
* CHECK dout0_13 vdout0_13ck67 = 0 time = 680
* CHECK dout0_14 vdout0_14ck67 = 0 time = 680
* CHECK dout0_15 vdout0_15ck67 = 1.6 time = 680
* CHECK dout0_16 vdout0_16ck67 = 0 time = 680
* CHECK dout0_17 vdout0_17ck67 = 0 time = 680
* CHECK dout0_18 vdout0_18ck67 = 0 time = 680
* CHECK dout0_19 vdout0_19ck67 = 0 time = 680
* CHECK dout0_20 vdout0_20ck67 = 1.6 time = 680
* CHECK dout0_21 vdout0_21ck67 = 1.6 time = 680
* CHECK dout0_22 vdout0_22ck67 = 0 time = 680
* CHECK dout0_23 vdout0_23ck67 = 1.6 time = 680
* CHECK dout0_24 vdout0_24ck67 = 1.6 time = 680
* CHECK dout0_25 vdout0_25ck67 = 1.6 time = 680
* CHECK dout0_26 vdout0_26ck67 = 0 time = 680
* CHECK dout0_27 vdout0_27ck67 = 1.6 time = 680
* CHECK dout0_28 vdout0_28ck67 = 0 time = 680
* CHECK dout0_29 vdout0_29ck67 = 1.6 time = 680
* CHECK dout0_30 vdout0_30ck67 = 0 time = 680
* CHECK dout0_31 vdout0_31ck67 = 0 time = 680
* CHECK dout0_32 vdout0_32ck67 = 0 time = 680
* CHECK dout1_0 vdout1_0ck67 = 1.6 time = 680
* CHECK dout1_1 vdout1_1ck67 = 0 time = 680
* CHECK dout1_2 vdout1_2ck67 = 0 time = 680
* CHECK dout1_3 vdout1_3ck67 = 0 time = 680
* CHECK dout1_4 vdout1_4ck67 = 0 time = 680
* CHECK dout1_5 vdout1_5ck67 = 0 time = 680
* CHECK dout1_6 vdout1_6ck67 = 1.6 time = 680
* CHECK dout1_7 vdout1_7ck67 = 1.6 time = 680
* CHECK dout1_8 vdout1_8ck67 = 1.6 time = 680
* CHECK dout1_9 vdout1_9ck67 = 1.6 time = 680
* CHECK dout1_10 vdout1_10ck67 = 1.6 time = 680
* CHECK dout1_11 vdout1_11ck67 = 1.6 time = 680
* CHECK dout1_12 vdout1_12ck67 = 1.6 time = 680
* CHECK dout1_13 vdout1_13ck67 = 0 time = 680
* CHECK dout1_14 vdout1_14ck67 = 0 time = 680
* CHECK dout1_15 vdout1_15ck67 = 1.6 time = 680
* CHECK dout1_16 vdout1_16ck67 = 0 time = 680
* CHECK dout1_17 vdout1_17ck67 = 0 time = 680
* CHECK dout1_18 vdout1_18ck67 = 0 time = 680
* CHECK dout1_19 vdout1_19ck67 = 0 time = 680
* CHECK dout1_20 vdout1_20ck67 = 1.6 time = 680
* CHECK dout1_21 vdout1_21ck67 = 1.6 time = 680
* CHECK dout1_22 vdout1_22ck67 = 0 time = 680
* CHECK dout1_23 vdout1_23ck67 = 1.6 time = 680
* CHECK dout1_24 vdout1_24ck67 = 1.6 time = 680
* CHECK dout1_25 vdout1_25ck67 = 1.6 time = 680
* CHECK dout1_26 vdout1_26ck67 = 0 time = 680
* CHECK dout1_27 vdout1_27ck67 = 1.6 time = 680
* CHECK dout1_28 vdout1_28ck67 = 0 time = 680
* CHECK dout1_29 vdout1_29ck67 = 1.6 time = 680
* CHECK dout1_30 vdout1_30ck67 = 0 time = 680
* CHECK dout1_31 vdout1_31ck67 = 0 time = 680
* CHECK dout1_32 vdout1_32ck67 = 0 time = 680
* CHECK dout0_0 vdout0_0ck69 = 1.6 time = 700
* CHECK dout0_1 vdout0_1ck69 = 1.6 time = 700
* CHECK dout0_2 vdout0_2ck69 = 1.6 time = 700
* CHECK dout0_3 vdout0_3ck69 = 1.6 time = 700
* CHECK dout0_4 vdout0_4ck69 = 1.6 time = 700
* CHECK dout0_5 vdout0_5ck69 = 0 time = 700
* CHECK dout0_6 vdout0_6ck69 = 0 time = 700
* CHECK dout0_7 vdout0_7ck69 = 1.6 time = 700
* CHECK dout0_8 vdout0_8ck69 = 1.6 time = 700
* CHECK dout0_9 vdout0_9ck69 = 0 time = 700
* CHECK dout0_10 vdout0_10ck69 = 0 time = 700
* CHECK dout0_11 vdout0_11ck69 = 1.6 time = 700
* CHECK dout0_12 vdout0_12ck69 = 0 time = 700
* CHECK dout0_13 vdout0_13ck69 = 0 time = 700
* CHECK dout0_14 vdout0_14ck69 = 0 time = 700
* CHECK dout0_15 vdout0_15ck69 = 0 time = 700
* CHECK dout0_16 vdout0_16ck69 = 1.6 time = 700
* CHECK dout0_17 vdout0_17ck69 = 1.6 time = 700
* CHECK dout0_18 vdout0_18ck69 = 1.6 time = 700
* CHECK dout0_19 vdout0_19ck69 = 0 time = 700
* CHECK dout0_20 vdout0_20ck69 = 0 time = 700
* CHECK dout0_21 vdout0_21ck69 = 0 time = 700
* CHECK dout0_22 vdout0_22ck69 = 1.6 time = 700
* CHECK dout0_23 vdout0_23ck69 = 0 time = 700
* CHECK dout0_24 vdout0_24ck69 = 1.6 time = 700
* CHECK dout0_25 vdout0_25ck69 = 1.6 time = 700
* CHECK dout0_26 vdout0_26ck69 = 1.6 time = 700
* CHECK dout0_27 vdout0_27ck69 = 0 time = 700
* CHECK dout0_28 vdout0_28ck69 = 1.6 time = 700
* CHECK dout0_29 vdout0_29ck69 = 0 time = 700
* CHECK dout0_30 vdout0_30ck69 = 1.6 time = 700
* CHECK dout0_31 vdout0_31ck69 = 1.6 time = 700
* CHECK dout0_32 vdout0_32ck69 = 0 time = 700
* CHECK dout0_0 vdout0_0ck70 = 0 time = 710
* CHECK dout0_1 vdout0_1ck70 = 1.6 time = 710
* CHECK dout0_2 vdout0_2ck70 = 1.6 time = 710
* CHECK dout0_3 vdout0_3ck70 = 1.6 time = 710
* CHECK dout0_4 vdout0_4ck70 = 0 time = 710
* CHECK dout0_5 vdout0_5ck70 = 0 time = 710
* CHECK dout0_6 vdout0_6ck70 = 0 time = 710
* CHECK dout0_7 vdout0_7ck70 = 1.6 time = 710
* CHECK dout0_8 vdout0_8ck70 = 0 time = 710
* CHECK dout0_9 vdout0_9ck70 = 1.6 time = 710
* CHECK dout0_10 vdout0_10ck70 = 1.6 time = 710
* CHECK dout0_11 vdout0_11ck70 = 1.6 time = 710
* CHECK dout0_12 vdout0_12ck70 = 0 time = 710
* CHECK dout0_13 vdout0_13ck70 = 1.6 time = 710
* CHECK dout0_14 vdout0_14ck70 = 1.6 time = 710
* CHECK dout0_15 vdout0_15ck70 = 0 time = 710
* CHECK dout0_16 vdout0_16ck70 = 0 time = 710
* CHECK dout0_17 vdout0_17ck70 = 0 time = 710
* CHECK dout0_18 vdout0_18ck70 = 1.6 time = 710
* CHECK dout0_19 vdout0_19ck70 = 1.6 time = 710
* CHECK dout0_20 vdout0_20ck70 = 0 time = 710
* CHECK dout0_21 vdout0_21ck70 = 1.6 time = 710
* CHECK dout0_22 vdout0_22ck70 = 1.6 time = 710
* CHECK dout0_23 vdout0_23ck70 = 1.6 time = 710
* CHECK dout0_24 vdout0_24ck70 = 1.6 time = 710
* CHECK dout0_25 vdout0_25ck70 = 1.6 time = 710
* CHECK dout0_26 vdout0_26ck70 = 1.6 time = 710
* CHECK dout0_27 vdout0_27ck70 = 0 time = 710
* CHECK dout0_28 vdout0_28ck70 = 0 time = 710
* CHECK dout0_29 vdout0_29ck70 = 1.6 time = 710
* CHECK dout0_30 vdout0_30ck70 = 0 time = 710
* CHECK dout0_31 vdout0_31ck70 = 0 time = 710
* CHECK dout0_32 vdout0_32ck70 = 0 time = 710
* CHECK dout1_0 vdout1_0ck70 = 1.6 time = 710
* CHECK dout1_1 vdout1_1ck70 = 1.6 time = 710
* CHECK dout1_2 vdout1_2ck70 = 0 time = 710
* CHECK dout1_3 vdout1_3ck70 = 1.6 time = 710
* CHECK dout1_4 vdout1_4ck70 = 1.6 time = 710
* CHECK dout1_5 vdout1_5ck70 = 1.6 time = 710
* CHECK dout1_6 vdout1_6ck70 = 1.6 time = 710
* CHECK dout1_7 vdout1_7ck70 = 0 time = 710
* CHECK dout1_8 vdout1_8ck70 = 0 time = 710
* CHECK dout1_9 vdout1_9ck70 = 1.6 time = 710
* CHECK dout1_10 vdout1_10ck70 = 1.6 time = 710
* CHECK dout1_11 vdout1_11ck70 = 1.6 time = 710
* CHECK dout1_12 vdout1_12ck70 = 1.6 time = 710
* CHECK dout1_13 vdout1_13ck70 = 0 time = 710
* CHECK dout1_14 vdout1_14ck70 = 1.6 time = 710
* CHECK dout1_15 vdout1_15ck70 = 0 time = 710
* CHECK dout1_16 vdout1_16ck70 = 0 time = 710
* CHECK dout1_17 vdout1_17ck70 = 1.6 time = 710
* CHECK dout1_18 vdout1_18ck70 = 0 time = 710
* CHECK dout1_19 vdout1_19ck70 = 1.6 time = 710
* CHECK dout1_20 vdout1_20ck70 = 0 time = 710
* CHECK dout1_21 vdout1_21ck70 = 0 time = 710
* CHECK dout1_22 vdout1_22ck70 = 1.6 time = 710
* CHECK dout1_23 vdout1_23ck70 = 0 time = 710
* CHECK dout1_24 vdout1_24ck70 = 1.6 time = 710
* CHECK dout1_25 vdout1_25ck70 = 1.6 time = 710
* CHECK dout1_26 vdout1_26ck70 = 1.6 time = 710
* CHECK dout1_27 vdout1_27ck70 = 0 time = 710
* CHECK dout1_28 vdout1_28ck70 = 0 time = 710
* CHECK dout1_29 vdout1_29ck70 = 1.6 time = 710
* CHECK dout1_30 vdout1_30ck70 = 0 time = 710
* CHECK dout1_31 vdout1_31ck70 = 0 time = 710
* CHECK dout1_32 vdout1_32ck70 = 0 time = 710
* CHECK dout0_0 vdout0_0ck71 = 1.6 time = 720
* CHECK dout0_1 vdout0_1ck71 = 0 time = 720
* CHECK dout0_2 vdout0_2ck71 = 0 time = 720
* CHECK dout0_3 vdout0_3ck71 = 0 time = 720
* CHECK dout0_4 vdout0_4ck71 = 0 time = 720
* CHECK dout0_5 vdout0_5ck71 = 0 time = 720
* CHECK dout0_6 vdout0_6ck71 = 1.6 time = 720
* CHECK dout0_7 vdout0_7ck71 = 1.6 time = 720
* CHECK dout0_8 vdout0_8ck71 = 1.6 time = 720
* CHECK dout0_9 vdout0_9ck71 = 1.6 time = 720
* CHECK dout0_10 vdout0_10ck71 = 1.6 time = 720
* CHECK dout0_11 vdout0_11ck71 = 1.6 time = 720
* CHECK dout0_12 vdout0_12ck71 = 1.6 time = 720
* CHECK dout0_13 vdout0_13ck71 = 0 time = 720
* CHECK dout0_14 vdout0_14ck71 = 0 time = 720
* CHECK dout0_15 vdout0_15ck71 = 1.6 time = 720
* CHECK dout0_16 vdout0_16ck71 = 0 time = 720
* CHECK dout0_17 vdout0_17ck71 = 0 time = 720
* CHECK dout0_18 vdout0_18ck71 = 0 time = 720
* CHECK dout0_19 vdout0_19ck71 = 0 time = 720
* CHECK dout0_20 vdout0_20ck71 = 1.6 time = 720
* CHECK dout0_21 vdout0_21ck71 = 1.6 time = 720
* CHECK dout0_22 vdout0_22ck71 = 0 time = 720
* CHECK dout0_23 vdout0_23ck71 = 1.6 time = 720
* CHECK dout0_24 vdout0_24ck71 = 1.6 time = 720
* CHECK dout0_25 vdout0_25ck71 = 1.6 time = 720
* CHECK dout0_26 vdout0_26ck71 = 0 time = 720
* CHECK dout0_27 vdout0_27ck71 = 1.6 time = 720
* CHECK dout0_28 vdout0_28ck71 = 0 time = 720
* CHECK dout0_29 vdout0_29ck71 = 1.6 time = 720
* CHECK dout0_30 vdout0_30ck71 = 0 time = 720
* CHECK dout0_31 vdout0_31ck71 = 0 time = 720
* CHECK dout0_32 vdout0_32ck71 = 0 time = 720
* CHECK dout1_0 vdout1_0ck72 = 0 time = 730
* CHECK dout1_1 vdout1_1ck72 = 1.6 time = 730
* CHECK dout1_2 vdout1_2ck72 = 1.6 time = 730
* CHECK dout1_3 vdout1_3ck72 = 1.6 time = 730
* CHECK dout1_4 vdout1_4ck72 = 0 time = 730
* CHECK dout1_5 vdout1_5ck72 = 0 time = 730
* CHECK dout1_6 vdout1_6ck72 = 0 time = 730
* CHECK dout1_7 vdout1_7ck72 = 1.6 time = 730
* CHECK dout1_8 vdout1_8ck72 = 0 time = 730
* CHECK dout1_9 vdout1_9ck72 = 1.6 time = 730
* CHECK dout1_10 vdout1_10ck72 = 1.6 time = 730
* CHECK dout1_11 vdout1_11ck72 = 1.6 time = 730
* CHECK dout1_12 vdout1_12ck72 = 0 time = 730
* CHECK dout1_13 vdout1_13ck72 = 1.6 time = 730
* CHECK dout1_14 vdout1_14ck72 = 1.6 time = 730
* CHECK dout1_15 vdout1_15ck72 = 0 time = 730
* CHECK dout1_16 vdout1_16ck72 = 0 time = 730
* CHECK dout1_17 vdout1_17ck72 = 0 time = 730
* CHECK dout1_18 vdout1_18ck72 = 1.6 time = 730
* CHECK dout1_19 vdout1_19ck72 = 1.6 time = 730
* CHECK dout1_20 vdout1_20ck72 = 0 time = 730
* CHECK dout1_21 vdout1_21ck72 = 1.6 time = 730
* CHECK dout1_22 vdout1_22ck72 = 1.6 time = 730
* CHECK dout1_23 vdout1_23ck72 = 1.6 time = 730
* CHECK dout1_24 vdout1_24ck72 = 1.6 time = 730
* CHECK dout1_25 vdout1_25ck72 = 1.6 time = 730
* CHECK dout1_26 vdout1_26ck72 = 1.6 time = 730
* CHECK dout1_27 vdout1_27ck72 = 0 time = 730
* CHECK dout1_28 vdout1_28ck72 = 0 time = 730
* CHECK dout1_29 vdout1_29ck72 = 1.6 time = 730
* CHECK dout1_30 vdout1_30ck72 = 0 time = 730
* CHECK dout1_31 vdout1_31ck72 = 0 time = 730
* CHECK dout1_32 vdout1_32ck72 = 0 time = 730
* CHECK dout0_0 vdout0_0ck73 = 1.6 time = 740
* CHECK dout0_1 vdout0_1ck73 = 1.6 time = 740
* CHECK dout0_2 vdout0_2ck73 = 0 time = 740
* CHECK dout0_3 vdout0_3ck73 = 1.6 time = 740
* CHECK dout0_4 vdout0_4ck73 = 1.6 time = 740
* CHECK dout0_5 vdout0_5ck73 = 1.6 time = 740
* CHECK dout0_6 vdout0_6ck73 = 1.6 time = 740
* CHECK dout0_7 vdout0_7ck73 = 0 time = 740
* CHECK dout0_8 vdout0_8ck73 = 0 time = 740
* CHECK dout0_9 vdout0_9ck73 = 1.6 time = 740
* CHECK dout0_10 vdout0_10ck73 = 1.6 time = 740
* CHECK dout0_11 vdout0_11ck73 = 1.6 time = 740
* CHECK dout0_12 vdout0_12ck73 = 1.6 time = 740
* CHECK dout0_13 vdout0_13ck73 = 0 time = 740
* CHECK dout0_14 vdout0_14ck73 = 1.6 time = 740
* CHECK dout0_15 vdout0_15ck73 = 0 time = 740
* CHECK dout0_16 vdout0_16ck73 = 0 time = 740
* CHECK dout0_17 vdout0_17ck73 = 1.6 time = 740
* CHECK dout0_18 vdout0_18ck73 = 0 time = 740
* CHECK dout0_19 vdout0_19ck73 = 1.6 time = 740
* CHECK dout0_20 vdout0_20ck73 = 0 time = 740
* CHECK dout0_21 vdout0_21ck73 = 0 time = 740
* CHECK dout0_22 vdout0_22ck73 = 1.6 time = 740
* CHECK dout0_23 vdout0_23ck73 = 0 time = 740
* CHECK dout0_24 vdout0_24ck73 = 1.6 time = 740
* CHECK dout0_25 vdout0_25ck73 = 1.6 time = 740
* CHECK dout0_26 vdout0_26ck73 = 1.6 time = 740
* CHECK dout0_27 vdout0_27ck73 = 0 time = 740
* CHECK dout0_28 vdout0_28ck73 = 0 time = 740
* CHECK dout0_29 vdout0_29ck73 = 1.6 time = 740
* CHECK dout0_30 vdout0_30ck73 = 0 time = 740
* CHECK dout0_31 vdout0_31ck73 = 0 time = 740
* CHECK dout0_32 vdout0_32ck73 = 0 time = 740
* CHECK dout1_0 vdout1_0ck73 = 1.6 time = 740
* CHECK dout1_1 vdout1_1ck73 = 1.6 time = 740
* CHECK dout1_2 vdout1_2ck73 = 1.6 time = 740
* CHECK dout1_3 vdout1_3ck73 = 1.6 time = 740
* CHECK dout1_4 vdout1_4ck73 = 1.6 time = 740
* CHECK dout1_5 vdout1_5ck73 = 0 time = 740
* CHECK dout1_6 vdout1_6ck73 = 0 time = 740
* CHECK dout1_7 vdout1_7ck73 = 1.6 time = 740
* CHECK dout1_8 vdout1_8ck73 = 1.6 time = 740
* CHECK dout1_9 vdout1_9ck73 = 0 time = 740
* CHECK dout1_10 vdout1_10ck73 = 0 time = 740
* CHECK dout1_11 vdout1_11ck73 = 1.6 time = 740
* CHECK dout1_12 vdout1_12ck73 = 0 time = 740
* CHECK dout1_13 vdout1_13ck73 = 0 time = 740
* CHECK dout1_14 vdout1_14ck73 = 0 time = 740
* CHECK dout1_15 vdout1_15ck73 = 0 time = 740
* CHECK dout1_16 vdout1_16ck73 = 1.6 time = 740
* CHECK dout1_17 vdout1_17ck73 = 1.6 time = 740
* CHECK dout1_18 vdout1_18ck73 = 1.6 time = 740
* CHECK dout1_19 vdout1_19ck73 = 0 time = 740
* CHECK dout1_20 vdout1_20ck73 = 0 time = 740
* CHECK dout1_21 vdout1_21ck73 = 0 time = 740
* CHECK dout1_22 vdout1_22ck73 = 1.6 time = 740
* CHECK dout1_23 vdout1_23ck73 = 0 time = 740
* CHECK dout1_24 vdout1_24ck73 = 1.6 time = 740
* CHECK dout1_25 vdout1_25ck73 = 1.6 time = 740
* CHECK dout1_26 vdout1_26ck73 = 1.6 time = 740
* CHECK dout1_27 vdout1_27ck73 = 0 time = 740
* CHECK dout1_28 vdout1_28ck73 = 1.6 time = 740
* CHECK dout1_29 vdout1_29ck73 = 0 time = 740
* CHECK dout1_30 vdout1_30ck73 = 1.6 time = 740
* CHECK dout1_31 vdout1_31ck73 = 1.6 time = 740
* CHECK dout1_32 vdout1_32ck73 = 0 time = 740
* CHECK dout1_0 vdout1_0ck74 = 1.6 time = 750
* CHECK dout1_1 vdout1_1ck74 = 1.6 time = 750
* CHECK dout1_2 vdout1_2ck74 = 0 time = 750
* CHECK dout1_3 vdout1_3ck74 = 1.6 time = 750
* CHECK dout1_4 vdout1_4ck74 = 1.6 time = 750
* CHECK dout1_5 vdout1_5ck74 = 1.6 time = 750
* CHECK dout1_6 vdout1_6ck74 = 1.6 time = 750
* CHECK dout1_7 vdout1_7ck74 = 0 time = 750
* CHECK dout1_8 vdout1_8ck74 = 0 time = 750
* CHECK dout1_9 vdout1_9ck74 = 1.6 time = 750
* CHECK dout1_10 vdout1_10ck74 = 1.6 time = 750
* CHECK dout1_11 vdout1_11ck74 = 1.6 time = 750
* CHECK dout1_12 vdout1_12ck74 = 1.6 time = 750
* CHECK dout1_13 vdout1_13ck74 = 0 time = 750
* CHECK dout1_14 vdout1_14ck74 = 1.6 time = 750
* CHECK dout1_15 vdout1_15ck74 = 0 time = 750
* CHECK dout1_16 vdout1_16ck74 = 0 time = 750
* CHECK dout1_17 vdout1_17ck74 = 1.6 time = 750
* CHECK dout1_18 vdout1_18ck74 = 0 time = 750
* CHECK dout1_19 vdout1_19ck74 = 1.6 time = 750
* CHECK dout1_20 vdout1_20ck74 = 0 time = 750
* CHECK dout1_21 vdout1_21ck74 = 0 time = 750
* CHECK dout1_22 vdout1_22ck74 = 1.6 time = 750
* CHECK dout1_23 vdout1_23ck74 = 0 time = 750
* CHECK dout1_24 vdout1_24ck74 = 1.6 time = 750
* CHECK dout1_25 vdout1_25ck74 = 1.6 time = 750
* CHECK dout1_26 vdout1_26ck74 = 1.6 time = 750
* CHECK dout1_27 vdout1_27ck74 = 0 time = 750
* CHECK dout1_28 vdout1_28ck74 = 0 time = 750
* CHECK dout1_29 vdout1_29ck74 = 1.6 time = 750
* CHECK dout1_30 vdout1_30ck74 = 0 time = 750
* CHECK dout1_31 vdout1_31ck74 = 0 time = 750
* CHECK dout1_32 vdout1_32ck74 = 0 time = 750
* CHECK dout0_0 vdout0_0ck75 = 0 time = 760
* CHECK dout0_1 vdout0_1ck75 = 1.6 time = 760
* CHECK dout0_2 vdout0_2ck75 = 1.6 time = 760
* CHECK dout0_3 vdout0_3ck75 = 1.6 time = 760
* CHECK dout0_4 vdout0_4ck75 = 0 time = 760
* CHECK dout0_5 vdout0_5ck75 = 0 time = 760
* CHECK dout0_6 vdout0_6ck75 = 0 time = 760
* CHECK dout0_7 vdout0_7ck75 = 1.6 time = 760
* CHECK dout0_8 vdout0_8ck75 = 0 time = 760
* CHECK dout0_9 vdout0_9ck75 = 1.6 time = 760
* CHECK dout0_10 vdout0_10ck75 = 1.6 time = 760
* CHECK dout0_11 vdout0_11ck75 = 1.6 time = 760
* CHECK dout0_12 vdout0_12ck75 = 0 time = 760
* CHECK dout0_13 vdout0_13ck75 = 1.6 time = 760
* CHECK dout0_14 vdout0_14ck75 = 1.6 time = 760
* CHECK dout0_15 vdout0_15ck75 = 0 time = 760
* CHECK dout0_16 vdout0_16ck75 = 0 time = 760
* CHECK dout0_17 vdout0_17ck75 = 0 time = 760
* CHECK dout0_18 vdout0_18ck75 = 1.6 time = 760
* CHECK dout0_19 vdout0_19ck75 = 1.6 time = 760
* CHECK dout0_20 vdout0_20ck75 = 0 time = 760
* CHECK dout0_21 vdout0_21ck75 = 1.6 time = 760
* CHECK dout0_22 vdout0_22ck75 = 1.6 time = 760
* CHECK dout0_23 vdout0_23ck75 = 1.6 time = 760
* CHECK dout0_24 vdout0_24ck75 = 1.6 time = 760
* CHECK dout0_25 vdout0_25ck75 = 1.6 time = 760
* CHECK dout0_26 vdout0_26ck75 = 1.6 time = 760
* CHECK dout0_27 vdout0_27ck75 = 0 time = 760
* CHECK dout0_28 vdout0_28ck75 = 0 time = 760
* CHECK dout0_29 vdout0_29ck75 = 1.6 time = 760
* CHECK dout0_30 vdout0_30ck75 = 0 time = 760
* CHECK dout0_31 vdout0_31ck75 = 0 time = 760
* CHECK dout0_32 vdout0_32ck75 = 0 time = 760
* CHECK dout0_0 vdout0_0ck76 = 0 time = 770
* CHECK dout0_1 vdout0_1ck76 = 1.6 time = 770
* CHECK dout0_2 vdout0_2ck76 = 1.6 time = 770
* CHECK dout0_3 vdout0_3ck76 = 1.6 time = 770
* CHECK dout0_4 vdout0_4ck76 = 0 time = 770
* CHECK dout0_5 vdout0_5ck76 = 0 time = 770
* CHECK dout0_6 vdout0_6ck76 = 0 time = 770
* CHECK dout0_7 vdout0_7ck76 = 1.6 time = 770
* CHECK dout0_8 vdout0_8ck76 = 0 time = 770
* CHECK dout0_9 vdout0_9ck76 = 1.6 time = 770
* CHECK dout0_10 vdout0_10ck76 = 1.6 time = 770
* CHECK dout0_11 vdout0_11ck76 = 1.6 time = 770
* CHECK dout0_12 vdout0_12ck76 = 0 time = 770
* CHECK dout0_13 vdout0_13ck76 = 1.6 time = 770
* CHECK dout0_14 vdout0_14ck76 = 1.6 time = 770
* CHECK dout0_15 vdout0_15ck76 = 0 time = 770
* CHECK dout0_16 vdout0_16ck76 = 0 time = 770
* CHECK dout0_17 vdout0_17ck76 = 0 time = 770
* CHECK dout0_18 vdout0_18ck76 = 1.6 time = 770
* CHECK dout0_19 vdout0_19ck76 = 1.6 time = 770
* CHECK dout0_20 vdout0_20ck76 = 0 time = 770
* CHECK dout0_21 vdout0_21ck76 = 1.6 time = 770
* CHECK dout0_22 vdout0_22ck76 = 1.6 time = 770
* CHECK dout0_23 vdout0_23ck76 = 1.6 time = 770
* CHECK dout0_24 vdout0_24ck76 = 1.6 time = 770
* CHECK dout0_25 vdout0_25ck76 = 1.6 time = 770
* CHECK dout0_26 vdout0_26ck76 = 1.6 time = 770
* CHECK dout0_27 vdout0_27ck76 = 0 time = 770
* CHECK dout0_28 vdout0_28ck76 = 0 time = 770
* CHECK dout0_29 vdout0_29ck76 = 1.6 time = 770
* CHECK dout0_30 vdout0_30ck76 = 0 time = 770
* CHECK dout0_31 vdout0_31ck76 = 0 time = 770
* CHECK dout0_32 vdout0_32ck76 = 0 time = 770
* CHECK dout1_0 vdout1_0ck76 = 1.6 time = 770
* CHECK dout1_1 vdout1_1ck76 = 0 time = 770
* CHECK dout1_2 vdout1_2ck76 = 0 time = 770
* CHECK dout1_3 vdout1_3ck76 = 0 time = 770
* CHECK dout1_4 vdout1_4ck76 = 0 time = 770
* CHECK dout1_5 vdout1_5ck76 = 0 time = 770
* CHECK dout1_6 vdout1_6ck76 = 1.6 time = 770
* CHECK dout1_7 vdout1_7ck76 = 1.6 time = 770
* CHECK dout1_8 vdout1_8ck76 = 1.6 time = 770
* CHECK dout1_9 vdout1_9ck76 = 1.6 time = 770
* CHECK dout1_10 vdout1_10ck76 = 1.6 time = 770
* CHECK dout1_11 vdout1_11ck76 = 1.6 time = 770
* CHECK dout1_12 vdout1_12ck76 = 1.6 time = 770
* CHECK dout1_13 vdout1_13ck76 = 0 time = 770
* CHECK dout1_14 vdout1_14ck76 = 0 time = 770
* CHECK dout1_15 vdout1_15ck76 = 1.6 time = 770
* CHECK dout1_16 vdout1_16ck76 = 0 time = 770
* CHECK dout1_17 vdout1_17ck76 = 0 time = 770
* CHECK dout1_18 vdout1_18ck76 = 0 time = 770
* CHECK dout1_19 vdout1_19ck76 = 0 time = 770
* CHECK dout1_20 vdout1_20ck76 = 1.6 time = 770
* CHECK dout1_21 vdout1_21ck76 = 1.6 time = 770
* CHECK dout1_22 vdout1_22ck76 = 0 time = 770
* CHECK dout1_23 vdout1_23ck76 = 1.6 time = 770
* CHECK dout1_24 vdout1_24ck76 = 1.6 time = 770
* CHECK dout1_25 vdout1_25ck76 = 1.6 time = 770
* CHECK dout1_26 vdout1_26ck76 = 0 time = 770
* CHECK dout1_27 vdout1_27ck76 = 1.6 time = 770
* CHECK dout1_28 vdout1_28ck76 = 0 time = 770
* CHECK dout1_29 vdout1_29ck76 = 1.6 time = 770
* CHECK dout1_30 vdout1_30ck76 = 0 time = 770
* CHECK dout1_31 vdout1_31ck76 = 0 time = 770
* CHECK dout1_32 vdout1_32ck76 = 0 time = 770
* CHECK dout0_0 vdout0_0ck77 = 1.6 time = 780
* CHECK dout0_1 vdout0_1ck77 = 1.6 time = 780
* CHECK dout0_2 vdout0_2ck77 = 1.6 time = 780
* CHECK dout0_3 vdout0_3ck77 = 1.6 time = 780
* CHECK dout0_4 vdout0_4ck77 = 1.6 time = 780
* CHECK dout0_5 vdout0_5ck77 = 0 time = 780
* CHECK dout0_6 vdout0_6ck77 = 0 time = 780
* CHECK dout0_7 vdout0_7ck77 = 1.6 time = 780
* CHECK dout0_8 vdout0_8ck77 = 1.6 time = 780
* CHECK dout0_9 vdout0_9ck77 = 0 time = 780
* CHECK dout0_10 vdout0_10ck77 = 0 time = 780
* CHECK dout0_11 vdout0_11ck77 = 1.6 time = 780
* CHECK dout0_12 vdout0_12ck77 = 0 time = 780
* CHECK dout0_13 vdout0_13ck77 = 0 time = 780
* CHECK dout0_14 vdout0_14ck77 = 0 time = 780
* CHECK dout0_15 vdout0_15ck77 = 0 time = 780
* CHECK dout0_16 vdout0_16ck77 = 1.6 time = 780
* CHECK dout0_17 vdout0_17ck77 = 1.6 time = 780
* CHECK dout0_18 vdout0_18ck77 = 1.6 time = 780
* CHECK dout0_19 vdout0_19ck77 = 0 time = 780
* CHECK dout0_20 vdout0_20ck77 = 0 time = 780
* CHECK dout0_21 vdout0_21ck77 = 0 time = 780
* CHECK dout0_22 vdout0_22ck77 = 1.6 time = 780
* CHECK dout0_23 vdout0_23ck77 = 0 time = 780
* CHECK dout0_24 vdout0_24ck77 = 1.6 time = 780
* CHECK dout0_25 vdout0_25ck77 = 1.6 time = 780
* CHECK dout0_26 vdout0_26ck77 = 1.6 time = 780
* CHECK dout0_27 vdout0_27ck77 = 0 time = 780
* CHECK dout0_28 vdout0_28ck77 = 1.6 time = 780
* CHECK dout0_29 vdout0_29ck77 = 0 time = 780
* CHECK dout0_30 vdout0_30ck77 = 1.6 time = 780
* CHECK dout0_31 vdout0_31ck77 = 1.6 time = 780
* CHECK dout0_32 vdout0_32ck77 = 0 time = 780
* CHECK dout0_0 vdout0_0ck78 = 1.6 time = 790
* CHECK dout0_1 vdout0_1ck78 = 1.6 time = 790
* CHECK dout0_2 vdout0_2ck78 = 1.6 time = 790
* CHECK dout0_3 vdout0_3ck78 = 1.6 time = 790
* CHECK dout0_4 vdout0_4ck78 = 1.6 time = 790
* CHECK dout0_5 vdout0_5ck78 = 0 time = 790
* CHECK dout0_6 vdout0_6ck78 = 0 time = 790
* CHECK dout0_7 vdout0_7ck78 = 1.6 time = 790
* CHECK dout0_8 vdout0_8ck78 = 1.6 time = 790
* CHECK dout0_9 vdout0_9ck78 = 0 time = 790
* CHECK dout0_10 vdout0_10ck78 = 0 time = 790
* CHECK dout0_11 vdout0_11ck78 = 1.6 time = 790
* CHECK dout0_12 vdout0_12ck78 = 0 time = 790
* CHECK dout0_13 vdout0_13ck78 = 0 time = 790
* CHECK dout0_14 vdout0_14ck78 = 0 time = 790
* CHECK dout0_15 vdout0_15ck78 = 0 time = 790
* CHECK dout0_16 vdout0_16ck78 = 1.6 time = 790
* CHECK dout0_17 vdout0_17ck78 = 1.6 time = 790
* CHECK dout0_18 vdout0_18ck78 = 1.6 time = 790
* CHECK dout0_19 vdout0_19ck78 = 0 time = 790
* CHECK dout0_20 vdout0_20ck78 = 0 time = 790
* CHECK dout0_21 vdout0_21ck78 = 0 time = 790
* CHECK dout0_22 vdout0_22ck78 = 1.6 time = 790
* CHECK dout0_23 vdout0_23ck78 = 0 time = 790
* CHECK dout0_24 vdout0_24ck78 = 1.6 time = 790
* CHECK dout0_25 vdout0_25ck78 = 1.6 time = 790
* CHECK dout0_26 vdout0_26ck78 = 1.6 time = 790
* CHECK dout0_27 vdout0_27ck78 = 0 time = 790
* CHECK dout0_28 vdout0_28ck78 = 1.6 time = 790
* CHECK dout0_29 vdout0_29ck78 = 0 time = 790
* CHECK dout0_30 vdout0_30ck78 = 1.6 time = 790
* CHECK dout0_31 vdout0_31ck78 = 1.6 time = 790
* CHECK dout0_32 vdout0_32ck78 = 0 time = 790
* CHECK dout1_0 vdout1_0ck78 = 1.6 time = 790
* CHECK dout1_1 vdout1_1ck78 = 0 time = 790
* CHECK dout1_2 vdout1_2ck78 = 0 time = 790
* CHECK dout1_3 vdout1_3ck78 = 0 time = 790
* CHECK dout1_4 vdout1_4ck78 = 0 time = 790
* CHECK dout1_5 vdout1_5ck78 = 0 time = 790
* CHECK dout1_6 vdout1_6ck78 = 1.6 time = 790
* CHECK dout1_7 vdout1_7ck78 = 1.6 time = 790
* CHECK dout1_8 vdout1_8ck78 = 1.6 time = 790
* CHECK dout1_9 vdout1_9ck78 = 1.6 time = 790
* CHECK dout1_10 vdout1_10ck78 = 1.6 time = 790
* CHECK dout1_11 vdout1_11ck78 = 1.6 time = 790
* CHECK dout1_12 vdout1_12ck78 = 1.6 time = 790
* CHECK dout1_13 vdout1_13ck78 = 0 time = 790
* CHECK dout1_14 vdout1_14ck78 = 0 time = 790
* CHECK dout1_15 vdout1_15ck78 = 1.6 time = 790
* CHECK dout1_16 vdout1_16ck78 = 0 time = 790
* CHECK dout1_17 vdout1_17ck78 = 0 time = 790
* CHECK dout1_18 vdout1_18ck78 = 0 time = 790
* CHECK dout1_19 vdout1_19ck78 = 0 time = 790
* CHECK dout1_20 vdout1_20ck78 = 1.6 time = 790
* CHECK dout1_21 vdout1_21ck78 = 1.6 time = 790
* CHECK dout1_22 vdout1_22ck78 = 0 time = 790
* CHECK dout1_23 vdout1_23ck78 = 1.6 time = 790
* CHECK dout1_24 vdout1_24ck78 = 1.6 time = 790
* CHECK dout1_25 vdout1_25ck78 = 1.6 time = 790
* CHECK dout1_26 vdout1_26ck78 = 0 time = 790
* CHECK dout1_27 vdout1_27ck78 = 1.6 time = 790
* CHECK dout1_28 vdout1_28ck78 = 0 time = 790
* CHECK dout1_29 vdout1_29ck78 = 1.6 time = 790
* CHECK dout1_30 vdout1_30ck78 = 0 time = 790
* CHECK dout1_31 vdout1_31ck78 = 0 time = 790
* CHECK dout1_32 vdout1_32ck78 = 0 time = 790
* CHECK dout0_0 vdout0_0ck79 = 0 time = 800
* CHECK dout0_1 vdout0_1ck79 = 1.6 time = 800
* CHECK dout0_2 vdout0_2ck79 = 1.6 time = 800
* CHECK dout0_3 vdout0_3ck79 = 1.6 time = 800
* CHECK dout0_4 vdout0_4ck79 = 0 time = 800
* CHECK dout0_5 vdout0_5ck79 = 0 time = 800
* CHECK dout0_6 vdout0_6ck79 = 0 time = 800
* CHECK dout0_7 vdout0_7ck79 = 1.6 time = 800
* CHECK dout0_8 vdout0_8ck79 = 0 time = 800
* CHECK dout0_9 vdout0_9ck79 = 1.6 time = 800
* CHECK dout0_10 vdout0_10ck79 = 1.6 time = 800
* CHECK dout0_11 vdout0_11ck79 = 1.6 time = 800
* CHECK dout0_12 vdout0_12ck79 = 0 time = 800
* CHECK dout0_13 vdout0_13ck79 = 1.6 time = 800
* CHECK dout0_14 vdout0_14ck79 = 1.6 time = 800
* CHECK dout0_15 vdout0_15ck79 = 0 time = 800
* CHECK dout0_16 vdout0_16ck79 = 0 time = 800
* CHECK dout0_17 vdout0_17ck79 = 0 time = 800
* CHECK dout0_18 vdout0_18ck79 = 1.6 time = 800
* CHECK dout0_19 vdout0_19ck79 = 1.6 time = 800
* CHECK dout0_20 vdout0_20ck79 = 0 time = 800
* CHECK dout0_21 vdout0_21ck79 = 1.6 time = 800
* CHECK dout0_22 vdout0_22ck79 = 1.6 time = 800
* CHECK dout0_23 vdout0_23ck79 = 1.6 time = 800
* CHECK dout0_24 vdout0_24ck79 = 1.6 time = 800
* CHECK dout0_25 vdout0_25ck79 = 1.6 time = 800
* CHECK dout0_26 vdout0_26ck79 = 1.6 time = 800
* CHECK dout0_27 vdout0_27ck79 = 0 time = 800
* CHECK dout0_28 vdout0_28ck79 = 0 time = 800
* CHECK dout0_29 vdout0_29ck79 = 1.6 time = 800
* CHECK dout0_30 vdout0_30ck79 = 0 time = 800
* CHECK dout0_31 vdout0_31ck79 = 0 time = 800
* CHECK dout0_32 vdout0_32ck79 = 0 time = 800
* CHECK dout0_0 vdout0_0ck81 = 1.6 time = 820
* CHECK dout0_1 vdout0_1ck81 = 1.6 time = 820
* CHECK dout0_2 vdout0_2ck81 = 1.6 time = 820
* CHECK dout0_3 vdout0_3ck81 = 1.6 time = 820
* CHECK dout0_4 vdout0_4ck81 = 1.6 time = 820
* CHECK dout0_5 vdout0_5ck81 = 0 time = 820
* CHECK dout0_6 vdout0_6ck81 = 0 time = 820
* CHECK dout0_7 vdout0_7ck81 = 1.6 time = 820
* CHECK dout0_8 vdout0_8ck81 = 1.6 time = 820
* CHECK dout0_9 vdout0_9ck81 = 0 time = 820
* CHECK dout0_10 vdout0_10ck81 = 0 time = 820
* CHECK dout0_11 vdout0_11ck81 = 1.6 time = 820
* CHECK dout0_12 vdout0_12ck81 = 0 time = 820
* CHECK dout0_13 vdout0_13ck81 = 0 time = 820
* CHECK dout0_14 vdout0_14ck81 = 0 time = 820
* CHECK dout0_15 vdout0_15ck81 = 0 time = 820
* CHECK dout0_16 vdout0_16ck81 = 1.6 time = 820
* CHECK dout0_17 vdout0_17ck81 = 1.6 time = 820
* CHECK dout0_18 vdout0_18ck81 = 1.6 time = 820
* CHECK dout0_19 vdout0_19ck81 = 0 time = 820
* CHECK dout0_20 vdout0_20ck81 = 0 time = 820
* CHECK dout0_21 vdout0_21ck81 = 0 time = 820
* CHECK dout0_22 vdout0_22ck81 = 1.6 time = 820
* CHECK dout0_23 vdout0_23ck81 = 0 time = 820
* CHECK dout0_24 vdout0_24ck81 = 1.6 time = 820
* CHECK dout0_25 vdout0_25ck81 = 1.6 time = 820
* CHECK dout0_26 vdout0_26ck81 = 1.6 time = 820
* CHECK dout0_27 vdout0_27ck81 = 0 time = 820
* CHECK dout0_28 vdout0_28ck81 = 1.6 time = 820
* CHECK dout0_29 vdout0_29ck81 = 0 time = 820
* CHECK dout0_30 vdout0_30ck81 = 1.6 time = 820
* CHECK dout0_31 vdout0_31ck81 = 1.6 time = 820
* CHECK dout0_32 vdout0_32ck81 = 0 time = 820
* CHECK dout0_0 vdout0_0ck82 = 0 time = 830
* CHECK dout0_1 vdout0_1ck82 = 1.6 time = 830
* CHECK dout0_2 vdout0_2ck82 = 1.6 time = 830
* CHECK dout0_3 vdout0_3ck82 = 1.6 time = 830
* CHECK dout0_4 vdout0_4ck82 = 0 time = 830
* CHECK dout0_5 vdout0_5ck82 = 0 time = 830
* CHECK dout0_6 vdout0_6ck82 = 0 time = 830
* CHECK dout0_7 vdout0_7ck82 = 1.6 time = 830
* CHECK dout0_8 vdout0_8ck82 = 0 time = 830
* CHECK dout0_9 vdout0_9ck82 = 1.6 time = 830
* CHECK dout0_10 vdout0_10ck82 = 1.6 time = 830
* CHECK dout0_11 vdout0_11ck82 = 1.6 time = 830
* CHECK dout0_12 vdout0_12ck82 = 0 time = 830
* CHECK dout0_13 vdout0_13ck82 = 1.6 time = 830
* CHECK dout0_14 vdout0_14ck82 = 1.6 time = 830
* CHECK dout0_15 vdout0_15ck82 = 0 time = 830
* CHECK dout0_16 vdout0_16ck82 = 0 time = 830
* CHECK dout0_17 vdout0_17ck82 = 0 time = 830
* CHECK dout0_18 vdout0_18ck82 = 1.6 time = 830
* CHECK dout0_19 vdout0_19ck82 = 1.6 time = 830
* CHECK dout0_20 vdout0_20ck82 = 0 time = 830
* CHECK dout0_21 vdout0_21ck82 = 1.6 time = 830
* CHECK dout0_22 vdout0_22ck82 = 1.6 time = 830
* CHECK dout0_23 vdout0_23ck82 = 1.6 time = 830
* CHECK dout0_24 vdout0_24ck82 = 1.6 time = 830
* CHECK dout0_25 vdout0_25ck82 = 1.6 time = 830
* CHECK dout0_26 vdout0_26ck82 = 1.6 time = 830
* CHECK dout0_27 vdout0_27ck82 = 0 time = 830
* CHECK dout0_28 vdout0_28ck82 = 0 time = 830
* CHECK dout0_29 vdout0_29ck82 = 1.6 time = 830
* CHECK dout0_30 vdout0_30ck82 = 0 time = 830
* CHECK dout0_31 vdout0_31ck82 = 0 time = 830
* CHECK dout0_32 vdout0_32ck82 = 0 time = 830
* CHECK dout1_0 vdout1_0ck82 = 1.6 time = 830
* CHECK dout1_1 vdout1_1ck82 = 1.6 time = 830
* CHECK dout1_2 vdout1_2ck82 = 1.6 time = 830
* CHECK dout1_3 vdout1_3ck82 = 1.6 time = 830
* CHECK dout1_4 vdout1_4ck82 = 1.6 time = 830
* CHECK dout1_5 vdout1_5ck82 = 0 time = 830
* CHECK dout1_6 vdout1_6ck82 = 0 time = 830
* CHECK dout1_7 vdout1_7ck82 = 1.6 time = 830
* CHECK dout1_8 vdout1_8ck82 = 1.6 time = 830
* CHECK dout1_9 vdout1_9ck82 = 0 time = 830
* CHECK dout1_10 vdout1_10ck82 = 0 time = 830
* CHECK dout1_11 vdout1_11ck82 = 1.6 time = 830
* CHECK dout1_12 vdout1_12ck82 = 0 time = 830
* CHECK dout1_13 vdout1_13ck82 = 0 time = 830
* CHECK dout1_14 vdout1_14ck82 = 0 time = 830
* CHECK dout1_15 vdout1_15ck82 = 0 time = 830
* CHECK dout1_16 vdout1_16ck82 = 1.6 time = 830
* CHECK dout1_17 vdout1_17ck82 = 1.6 time = 830
* CHECK dout1_18 vdout1_18ck82 = 1.6 time = 830
* CHECK dout1_19 vdout1_19ck82 = 0 time = 830
* CHECK dout1_20 vdout1_20ck82 = 0 time = 830
* CHECK dout1_21 vdout1_21ck82 = 0 time = 830
* CHECK dout1_22 vdout1_22ck82 = 1.6 time = 830
* CHECK dout1_23 vdout1_23ck82 = 0 time = 830
* CHECK dout1_24 vdout1_24ck82 = 1.6 time = 830
* CHECK dout1_25 vdout1_25ck82 = 1.6 time = 830
* CHECK dout1_26 vdout1_26ck82 = 1.6 time = 830
* CHECK dout1_27 vdout1_27ck82 = 0 time = 830
* CHECK dout1_28 vdout1_28ck82 = 1.6 time = 830
* CHECK dout1_29 vdout1_29ck82 = 0 time = 830
* CHECK dout1_30 vdout1_30ck82 = 1.6 time = 830
* CHECK dout1_31 vdout1_31ck82 = 1.6 time = 830
* CHECK dout1_32 vdout1_32ck82 = 0 time = 830
* CHECK dout0_0 vdout0_0ck84 = 1.6 time = 850
* CHECK dout0_1 vdout0_1ck84 = 1.6 time = 850
* CHECK dout0_2 vdout0_2ck84 = 0 time = 850
* CHECK dout0_3 vdout0_3ck84 = 1.6 time = 850
* CHECK dout0_4 vdout0_4ck84 = 1.6 time = 850
* CHECK dout0_5 vdout0_5ck84 = 1.6 time = 850
* CHECK dout0_6 vdout0_6ck84 = 1.6 time = 850
* CHECK dout0_7 vdout0_7ck84 = 0 time = 850
* CHECK dout0_8 vdout0_8ck84 = 0 time = 850
* CHECK dout0_9 vdout0_9ck84 = 1.6 time = 850
* CHECK dout0_10 vdout0_10ck84 = 1.6 time = 850
* CHECK dout0_11 vdout0_11ck84 = 1.6 time = 850
* CHECK dout0_12 vdout0_12ck84 = 1.6 time = 850
* CHECK dout0_13 vdout0_13ck84 = 0 time = 850
* CHECK dout0_14 vdout0_14ck84 = 1.6 time = 850
* CHECK dout0_15 vdout0_15ck84 = 0 time = 850
* CHECK dout0_16 vdout0_16ck84 = 0 time = 850
* CHECK dout0_17 vdout0_17ck84 = 1.6 time = 850
* CHECK dout0_18 vdout0_18ck84 = 0 time = 850
* CHECK dout0_19 vdout0_19ck84 = 1.6 time = 850
* CHECK dout0_20 vdout0_20ck84 = 0 time = 850
* CHECK dout0_21 vdout0_21ck84 = 0 time = 850
* CHECK dout0_22 vdout0_22ck84 = 1.6 time = 850
* CHECK dout0_23 vdout0_23ck84 = 0 time = 850
* CHECK dout0_24 vdout0_24ck84 = 1.6 time = 850
* CHECK dout0_25 vdout0_25ck84 = 1.6 time = 850
* CHECK dout0_26 vdout0_26ck84 = 1.6 time = 850
* CHECK dout0_27 vdout0_27ck84 = 0 time = 850
* CHECK dout0_28 vdout0_28ck84 = 0 time = 850
* CHECK dout0_29 vdout0_29ck84 = 1.6 time = 850
* CHECK dout0_30 vdout0_30ck84 = 0 time = 850
* CHECK dout0_31 vdout0_31ck84 = 0 time = 850
* CHECK dout0_32 vdout0_32ck84 = 0 time = 850
* CHECK dout0_0 vdout0_0ck85 = 1.6 time = 860
* CHECK dout0_1 vdout0_1ck85 = 1.6 time = 860
* CHECK dout0_2 vdout0_2ck85 = 1.6 time = 860
* CHECK dout0_3 vdout0_3ck85 = 1.6 time = 860
* CHECK dout0_4 vdout0_4ck85 = 1.6 time = 860
* CHECK dout0_5 vdout0_5ck85 = 0 time = 860
* CHECK dout0_6 vdout0_6ck85 = 0 time = 860
* CHECK dout0_7 vdout0_7ck85 = 1.6 time = 860
* CHECK dout0_8 vdout0_8ck85 = 1.6 time = 860
* CHECK dout0_9 vdout0_9ck85 = 0 time = 860
* CHECK dout0_10 vdout0_10ck85 = 0 time = 860
* CHECK dout0_11 vdout0_11ck85 = 1.6 time = 860
* CHECK dout0_12 vdout0_12ck85 = 0 time = 860
* CHECK dout0_13 vdout0_13ck85 = 0 time = 860
* CHECK dout0_14 vdout0_14ck85 = 0 time = 860
* CHECK dout0_15 vdout0_15ck85 = 0 time = 860
* CHECK dout0_16 vdout0_16ck85 = 1.6 time = 860
* CHECK dout0_17 vdout0_17ck85 = 1.6 time = 860
* CHECK dout0_18 vdout0_18ck85 = 1.6 time = 860
* CHECK dout0_19 vdout0_19ck85 = 0 time = 860
* CHECK dout0_20 vdout0_20ck85 = 0 time = 860
* CHECK dout0_21 vdout0_21ck85 = 0 time = 860
* CHECK dout0_22 vdout0_22ck85 = 1.6 time = 860
* CHECK dout0_23 vdout0_23ck85 = 0 time = 860
* CHECK dout0_24 vdout0_24ck85 = 1.6 time = 860
* CHECK dout0_25 vdout0_25ck85 = 1.6 time = 860
* CHECK dout0_26 vdout0_26ck85 = 1.6 time = 860
* CHECK dout0_27 vdout0_27ck85 = 0 time = 860
* CHECK dout0_28 vdout0_28ck85 = 1.6 time = 860
* CHECK dout0_29 vdout0_29ck85 = 0 time = 860
* CHECK dout0_30 vdout0_30ck85 = 1.6 time = 860
* CHECK dout0_31 vdout0_31ck85 = 1.6 time = 860
* CHECK dout0_32 vdout0_32ck85 = 0 time = 860
* CHECK dout1_0 vdout1_0ck85 = 1.6 time = 860
* CHECK dout1_1 vdout1_1ck85 = 1.6 time = 860
* CHECK dout1_2 vdout1_2ck85 = 0 time = 860
* CHECK dout1_3 vdout1_3ck85 = 1.6 time = 860
* CHECK dout1_4 vdout1_4ck85 = 1.6 time = 860
* CHECK dout1_5 vdout1_5ck85 = 1.6 time = 860
* CHECK dout1_6 vdout1_6ck85 = 1.6 time = 860
* CHECK dout1_7 vdout1_7ck85 = 0 time = 860
* CHECK dout1_8 vdout1_8ck85 = 0 time = 860
* CHECK dout1_9 vdout1_9ck85 = 1.6 time = 860
* CHECK dout1_10 vdout1_10ck85 = 1.6 time = 860
* CHECK dout1_11 vdout1_11ck85 = 1.6 time = 860
* CHECK dout1_12 vdout1_12ck85 = 1.6 time = 860
* CHECK dout1_13 vdout1_13ck85 = 0 time = 860
* CHECK dout1_14 vdout1_14ck85 = 1.6 time = 860
* CHECK dout1_15 vdout1_15ck85 = 0 time = 860
* CHECK dout1_16 vdout1_16ck85 = 0 time = 860
* CHECK dout1_17 vdout1_17ck85 = 1.6 time = 860
* CHECK dout1_18 vdout1_18ck85 = 0 time = 860
* CHECK dout1_19 vdout1_19ck85 = 1.6 time = 860
* CHECK dout1_20 vdout1_20ck85 = 0 time = 860
* CHECK dout1_21 vdout1_21ck85 = 0 time = 860
* CHECK dout1_22 vdout1_22ck85 = 1.6 time = 860
* CHECK dout1_23 vdout1_23ck85 = 0 time = 860
* CHECK dout1_24 vdout1_24ck85 = 1.6 time = 860
* CHECK dout1_25 vdout1_25ck85 = 1.6 time = 860
* CHECK dout1_26 vdout1_26ck85 = 1.6 time = 860
* CHECK dout1_27 vdout1_27ck85 = 0 time = 860
* CHECK dout1_28 vdout1_28ck85 = 0 time = 860
* CHECK dout1_29 vdout1_29ck85 = 1.6 time = 860
* CHECK dout1_30 vdout1_30ck85 = 0 time = 860
* CHECK dout1_31 vdout1_31ck85 = 0 time = 860
* CHECK dout1_32 vdout1_32ck85 = 0 time = 860
* CHECK dout1_0 vdout1_0ck86 = 1.6 time = 870
* CHECK dout1_1 vdout1_1ck86 = 1.6 time = 870
* CHECK dout1_2 vdout1_2ck86 = 0 time = 870
* CHECK dout1_3 vdout1_3ck86 = 1.6 time = 870
* CHECK dout1_4 vdout1_4ck86 = 1.6 time = 870
* CHECK dout1_5 vdout1_5ck86 = 1.6 time = 870
* CHECK dout1_6 vdout1_6ck86 = 1.6 time = 870
* CHECK dout1_7 vdout1_7ck86 = 0 time = 870
* CHECK dout1_8 vdout1_8ck86 = 0 time = 870
* CHECK dout1_9 vdout1_9ck86 = 1.6 time = 870
* CHECK dout1_10 vdout1_10ck86 = 1.6 time = 870
* CHECK dout1_11 vdout1_11ck86 = 1.6 time = 870
* CHECK dout1_12 vdout1_12ck86 = 1.6 time = 870
* CHECK dout1_13 vdout1_13ck86 = 0 time = 870
* CHECK dout1_14 vdout1_14ck86 = 1.6 time = 870
* CHECK dout1_15 vdout1_15ck86 = 0 time = 870
* CHECK dout1_16 vdout1_16ck86 = 0 time = 870
* CHECK dout1_17 vdout1_17ck86 = 1.6 time = 870
* CHECK dout1_18 vdout1_18ck86 = 0 time = 870
* CHECK dout1_19 vdout1_19ck86 = 1.6 time = 870
* CHECK dout1_20 vdout1_20ck86 = 0 time = 870
* CHECK dout1_21 vdout1_21ck86 = 0 time = 870
* CHECK dout1_22 vdout1_22ck86 = 1.6 time = 870
* CHECK dout1_23 vdout1_23ck86 = 0 time = 870
* CHECK dout1_24 vdout1_24ck86 = 1.6 time = 870
* CHECK dout1_25 vdout1_25ck86 = 1.6 time = 870
* CHECK dout1_26 vdout1_26ck86 = 1.6 time = 870
* CHECK dout1_27 vdout1_27ck86 = 0 time = 870
* CHECK dout1_28 vdout1_28ck86 = 0 time = 870
* CHECK dout1_29 vdout1_29ck86 = 1.6 time = 870
* CHECK dout1_30 vdout1_30ck86 = 0 time = 870
* CHECK dout1_31 vdout1_31ck86 = 0 time = 870
* CHECK dout1_32 vdout1_32ck86 = 0 time = 870
* CHECK dout1_0 vdout1_0ck87 = 1.6 time = 880
* CHECK dout1_1 vdout1_1ck87 = 1.6 time = 880
* CHECK dout1_2 vdout1_2ck87 = 1.6 time = 880
* CHECK dout1_3 vdout1_3ck87 = 1.6 time = 880
* CHECK dout1_4 vdout1_4ck87 = 1.6 time = 880
* CHECK dout1_5 vdout1_5ck87 = 0 time = 880
* CHECK dout1_6 vdout1_6ck87 = 0 time = 880
* CHECK dout1_7 vdout1_7ck87 = 1.6 time = 880
* CHECK dout1_8 vdout1_8ck87 = 1.6 time = 880
* CHECK dout1_9 vdout1_9ck87 = 0 time = 880
* CHECK dout1_10 vdout1_10ck87 = 0 time = 880
* CHECK dout1_11 vdout1_11ck87 = 1.6 time = 880
* CHECK dout1_12 vdout1_12ck87 = 0 time = 880
* CHECK dout1_13 vdout1_13ck87 = 0 time = 880
* CHECK dout1_14 vdout1_14ck87 = 0 time = 880
* CHECK dout1_15 vdout1_15ck87 = 0 time = 880
* CHECK dout1_16 vdout1_16ck87 = 1.6 time = 880
* CHECK dout1_17 vdout1_17ck87 = 1.6 time = 880
* CHECK dout1_18 vdout1_18ck87 = 1.6 time = 880
* CHECK dout1_19 vdout1_19ck87 = 0 time = 880
* CHECK dout1_20 vdout1_20ck87 = 0 time = 880
* CHECK dout1_21 vdout1_21ck87 = 0 time = 880
* CHECK dout1_22 vdout1_22ck87 = 1.6 time = 880
* CHECK dout1_23 vdout1_23ck87 = 0 time = 880
* CHECK dout1_24 vdout1_24ck87 = 1.6 time = 880
* CHECK dout1_25 vdout1_25ck87 = 1.6 time = 880
* CHECK dout1_26 vdout1_26ck87 = 1.6 time = 880
* CHECK dout1_27 vdout1_27ck87 = 0 time = 880
* CHECK dout1_28 vdout1_28ck87 = 1.6 time = 880
* CHECK dout1_29 vdout1_29ck87 = 0 time = 880
* CHECK dout1_30 vdout1_30ck87 = 1.6 time = 880
* CHECK dout1_31 vdout1_31ck87 = 1.6 time = 880
* CHECK dout1_32 vdout1_32ck87 = 0 time = 880
* CHECK dout0_0 vdout0_0ck88 = 1.6 time = 890
* CHECK dout0_1 vdout0_1ck88 = 1.6 time = 890
* CHECK dout0_2 vdout0_2ck88 = 1.6 time = 890
* CHECK dout0_3 vdout0_3ck88 = 1.6 time = 890
* CHECK dout0_4 vdout0_4ck88 = 1.6 time = 890
* CHECK dout0_5 vdout0_5ck88 = 0 time = 890
* CHECK dout0_6 vdout0_6ck88 = 0 time = 890
* CHECK dout0_7 vdout0_7ck88 = 1.6 time = 890
* CHECK dout0_8 vdout0_8ck88 = 1.6 time = 890
* CHECK dout0_9 vdout0_9ck88 = 0 time = 890
* CHECK dout0_10 vdout0_10ck88 = 0 time = 890
* CHECK dout0_11 vdout0_11ck88 = 1.6 time = 890
* CHECK dout0_12 vdout0_12ck88 = 0 time = 890
* CHECK dout0_13 vdout0_13ck88 = 0 time = 890
* CHECK dout0_14 vdout0_14ck88 = 0 time = 890
* CHECK dout0_15 vdout0_15ck88 = 0 time = 890
* CHECK dout0_16 vdout0_16ck88 = 1.6 time = 890
* CHECK dout0_17 vdout0_17ck88 = 1.6 time = 890
* CHECK dout0_18 vdout0_18ck88 = 1.6 time = 890
* CHECK dout0_19 vdout0_19ck88 = 0 time = 890
* CHECK dout0_20 vdout0_20ck88 = 0 time = 890
* CHECK dout0_21 vdout0_21ck88 = 0 time = 890
* CHECK dout0_22 vdout0_22ck88 = 1.6 time = 890
* CHECK dout0_23 vdout0_23ck88 = 0 time = 890
* CHECK dout0_24 vdout0_24ck88 = 1.6 time = 890
* CHECK dout0_25 vdout0_25ck88 = 1.6 time = 890
* CHECK dout0_26 vdout0_26ck88 = 1.6 time = 890
* CHECK dout0_27 vdout0_27ck88 = 0 time = 890
* CHECK dout0_28 vdout0_28ck88 = 1.6 time = 890
* CHECK dout0_29 vdout0_29ck88 = 0 time = 890
* CHECK dout0_30 vdout0_30ck88 = 1.6 time = 890
* CHECK dout0_31 vdout0_31ck88 = 1.6 time = 890
* CHECK dout0_32 vdout0_32ck88 = 0 time = 890
* CHECK dout1_0 vdout1_0ck88 = 1.6 time = 890
* CHECK dout1_1 vdout1_1ck88 = 1.6 time = 890
* CHECK dout1_2 vdout1_2ck88 = 1.6 time = 890
* CHECK dout1_3 vdout1_3ck88 = 0 time = 890
* CHECK dout1_4 vdout1_4ck88 = 0 time = 890
* CHECK dout1_5 vdout1_5ck88 = 0 time = 890
* CHECK dout1_6 vdout1_6ck88 = 0 time = 890
* CHECK dout1_7 vdout1_7ck88 = 1.6 time = 890
* CHECK dout1_8 vdout1_8ck88 = 0 time = 890
* CHECK dout1_9 vdout1_9ck88 = 0 time = 890
* CHECK dout1_10 vdout1_10ck88 = 1.6 time = 890
* CHECK dout1_11 vdout1_11ck88 = 1.6 time = 890
* CHECK dout1_12 vdout1_12ck88 = 0 time = 890
* CHECK dout1_13 vdout1_13ck88 = 1.6 time = 890
* CHECK dout1_14 vdout1_14ck88 = 0 time = 890
* CHECK dout1_15 vdout1_15ck88 = 1.6 time = 890
* CHECK dout1_16 vdout1_16ck88 = 1.6 time = 890
* CHECK dout1_17 vdout1_17ck88 = 0 time = 890
* CHECK dout1_18 vdout1_18ck88 = 1.6 time = 890
* CHECK dout1_19 vdout1_19ck88 = 1.6 time = 890
* CHECK dout1_20 vdout1_20ck88 = 1.6 time = 890
* CHECK dout1_21 vdout1_21ck88 = 1.6 time = 890
* CHECK dout1_22 vdout1_22ck88 = 1.6 time = 890
* CHECK dout1_23 vdout1_23ck88 = 1.6 time = 890
* CHECK dout1_24 vdout1_24ck88 = 0 time = 890
* CHECK dout1_25 vdout1_25ck88 = 1.6 time = 890
* CHECK dout1_26 vdout1_26ck88 = 0 time = 890
* CHECK dout1_27 vdout1_27ck88 = 0 time = 890
* CHECK dout1_28 vdout1_28ck88 = 1.6 time = 890
* CHECK dout1_29 vdout1_29ck88 = 0 time = 890
* CHECK dout1_30 vdout1_30ck88 = 1.6 time = 890
* CHECK dout1_31 vdout1_31ck88 = 0 time = 890
* CHECK dout1_32 vdout1_32ck88 = 0 time = 890
* CHECK dout0_0 vdout0_0ck89 = 1.6 time = 900
* CHECK dout0_1 vdout0_1ck89 = 1.6 time = 900
* CHECK dout0_2 vdout0_2ck89 = 1.6 time = 900
* CHECK dout0_3 vdout0_3ck89 = 0 time = 900
* CHECK dout0_4 vdout0_4ck89 = 0 time = 900
* CHECK dout0_5 vdout0_5ck89 = 0 time = 900
* CHECK dout0_6 vdout0_6ck89 = 0 time = 900
* CHECK dout0_7 vdout0_7ck89 = 1.6 time = 900
* CHECK dout0_8 vdout0_8ck89 = 0 time = 900
* CHECK dout0_9 vdout0_9ck89 = 0 time = 900
* CHECK dout0_10 vdout0_10ck89 = 1.6 time = 900
* CHECK dout0_11 vdout0_11ck89 = 1.6 time = 900
* CHECK dout0_12 vdout0_12ck89 = 0 time = 900
* CHECK dout0_13 vdout0_13ck89 = 1.6 time = 900
* CHECK dout0_14 vdout0_14ck89 = 0 time = 900
* CHECK dout0_15 vdout0_15ck89 = 1.6 time = 900
* CHECK dout0_16 vdout0_16ck89 = 1.6 time = 900
* CHECK dout0_17 vdout0_17ck89 = 0 time = 900
* CHECK dout0_18 vdout0_18ck89 = 1.6 time = 900
* CHECK dout0_19 vdout0_19ck89 = 1.6 time = 900
* CHECK dout0_20 vdout0_20ck89 = 1.6 time = 900
* CHECK dout0_21 vdout0_21ck89 = 1.6 time = 900
* CHECK dout0_22 vdout0_22ck89 = 1.6 time = 900
* CHECK dout0_23 vdout0_23ck89 = 1.6 time = 900
* CHECK dout0_24 vdout0_24ck89 = 0 time = 900
* CHECK dout0_25 vdout0_25ck89 = 1.6 time = 900
* CHECK dout0_26 vdout0_26ck89 = 0 time = 900
* CHECK dout0_27 vdout0_27ck89 = 0 time = 900
* CHECK dout0_28 vdout0_28ck89 = 1.6 time = 900
* CHECK dout0_29 vdout0_29ck89 = 0 time = 900
* CHECK dout0_30 vdout0_30ck89 = 1.6 time = 900
* CHECK dout0_31 vdout0_31ck89 = 0 time = 900
* CHECK dout0_32 vdout0_32ck89 = 0 time = 900
* CHECK dout1_0 vdout1_0ck90 = 1.6 time = 910
* CHECK dout1_1 vdout1_1ck90 = 1.6 time = 910
* CHECK dout1_2 vdout1_2ck90 = 0 time = 910
* CHECK dout1_3 vdout1_3ck90 = 1.6 time = 910
* CHECK dout1_4 vdout1_4ck90 = 1.6 time = 910
* CHECK dout1_5 vdout1_5ck90 = 1.6 time = 910
* CHECK dout1_6 vdout1_6ck90 = 1.6 time = 910
* CHECK dout1_7 vdout1_7ck90 = 0 time = 910
* CHECK dout1_8 vdout1_8ck90 = 0 time = 910
* CHECK dout1_9 vdout1_9ck90 = 1.6 time = 910
* CHECK dout1_10 vdout1_10ck90 = 1.6 time = 910
* CHECK dout1_11 vdout1_11ck90 = 1.6 time = 910
* CHECK dout1_12 vdout1_12ck90 = 1.6 time = 910
* CHECK dout1_13 vdout1_13ck90 = 0 time = 910
* CHECK dout1_14 vdout1_14ck90 = 1.6 time = 910
* CHECK dout1_15 vdout1_15ck90 = 0 time = 910
* CHECK dout1_16 vdout1_16ck90 = 0 time = 910
* CHECK dout1_17 vdout1_17ck90 = 1.6 time = 910
* CHECK dout1_18 vdout1_18ck90 = 0 time = 910
* CHECK dout1_19 vdout1_19ck90 = 1.6 time = 910
* CHECK dout1_20 vdout1_20ck90 = 0 time = 910
* CHECK dout1_21 vdout1_21ck90 = 0 time = 910
* CHECK dout1_22 vdout1_22ck90 = 1.6 time = 910
* CHECK dout1_23 vdout1_23ck90 = 0 time = 910
* CHECK dout1_24 vdout1_24ck90 = 1.6 time = 910
* CHECK dout1_25 vdout1_25ck90 = 1.6 time = 910
* CHECK dout1_26 vdout1_26ck90 = 1.6 time = 910
* CHECK dout1_27 vdout1_27ck90 = 0 time = 910
* CHECK dout1_28 vdout1_28ck90 = 0 time = 910
* CHECK dout1_29 vdout1_29ck90 = 1.6 time = 910
* CHECK dout1_30 vdout1_30ck90 = 0 time = 910
* CHECK dout1_31 vdout1_31ck90 = 0 time = 910
* CHECK dout1_32 vdout1_32ck90 = 0 time = 910
* CHECK dout1_0 vdout1_0ck91 = 1.6 time = 920
* CHECK dout1_1 vdout1_1ck91 = 1.6 time = 920
* CHECK dout1_2 vdout1_2ck91 = 1.6 time = 920
* CHECK dout1_3 vdout1_3ck91 = 1.6 time = 920
* CHECK dout1_4 vdout1_4ck91 = 1.6 time = 920
* CHECK dout1_5 vdout1_5ck91 = 0 time = 920
* CHECK dout1_6 vdout1_6ck91 = 0 time = 920
* CHECK dout1_7 vdout1_7ck91 = 1.6 time = 920
* CHECK dout1_8 vdout1_8ck91 = 1.6 time = 920
* CHECK dout1_9 vdout1_9ck91 = 0 time = 920
* CHECK dout1_10 vdout1_10ck91 = 0 time = 920
* CHECK dout1_11 vdout1_11ck91 = 1.6 time = 920
* CHECK dout1_12 vdout1_12ck91 = 0 time = 920
* CHECK dout1_13 vdout1_13ck91 = 0 time = 920
* CHECK dout1_14 vdout1_14ck91 = 0 time = 920
* CHECK dout1_15 vdout1_15ck91 = 0 time = 920
* CHECK dout1_16 vdout1_16ck91 = 1.6 time = 920
* CHECK dout1_17 vdout1_17ck91 = 1.6 time = 920
* CHECK dout1_18 vdout1_18ck91 = 1.6 time = 920
* CHECK dout1_19 vdout1_19ck91 = 0 time = 920
* CHECK dout1_20 vdout1_20ck91 = 0 time = 920
* CHECK dout1_21 vdout1_21ck91 = 0 time = 920
* CHECK dout1_22 vdout1_22ck91 = 1.6 time = 920
* CHECK dout1_23 vdout1_23ck91 = 0 time = 920
* CHECK dout1_24 vdout1_24ck91 = 1.6 time = 920
* CHECK dout1_25 vdout1_25ck91 = 1.6 time = 920
* CHECK dout1_26 vdout1_26ck91 = 1.6 time = 920
* CHECK dout1_27 vdout1_27ck91 = 0 time = 920
* CHECK dout1_28 vdout1_28ck91 = 1.6 time = 920
* CHECK dout1_29 vdout1_29ck91 = 0 time = 920
* CHECK dout1_30 vdout1_30ck91 = 1.6 time = 920
* CHECK dout1_31 vdout1_31ck91 = 1.6 time = 920
* CHECK dout1_32 vdout1_32ck91 = 0 time = 920
* CHECK dout0_0 vdout0_0ck92 = 1.6 time = 930
* CHECK dout0_1 vdout0_1ck92 = 1.6 time = 930
* CHECK dout0_2 vdout0_2ck92 = 1.6 time = 930
* CHECK dout0_3 vdout0_3ck92 = 0 time = 930
* CHECK dout0_4 vdout0_4ck92 = 0 time = 930
* CHECK dout0_5 vdout0_5ck92 = 0 time = 930
* CHECK dout0_6 vdout0_6ck92 = 0 time = 930
* CHECK dout0_7 vdout0_7ck92 = 1.6 time = 930
* CHECK dout0_8 vdout0_8ck92 = 0 time = 930
* CHECK dout0_9 vdout0_9ck92 = 0 time = 930
* CHECK dout0_10 vdout0_10ck92 = 1.6 time = 930
* CHECK dout0_11 vdout0_11ck92 = 1.6 time = 930
* CHECK dout0_12 vdout0_12ck92 = 0 time = 930
* CHECK dout0_13 vdout0_13ck92 = 1.6 time = 930
* CHECK dout0_14 vdout0_14ck92 = 0 time = 930
* CHECK dout0_15 vdout0_15ck92 = 1.6 time = 930
* CHECK dout0_16 vdout0_16ck92 = 1.6 time = 930
* CHECK dout0_17 vdout0_17ck92 = 0 time = 930
* CHECK dout0_18 vdout0_18ck92 = 1.6 time = 930
* CHECK dout0_19 vdout0_19ck92 = 1.6 time = 930
* CHECK dout0_20 vdout0_20ck92 = 1.6 time = 930
* CHECK dout0_21 vdout0_21ck92 = 1.6 time = 930
* CHECK dout0_22 vdout0_22ck92 = 1.6 time = 930
* CHECK dout0_23 vdout0_23ck92 = 1.6 time = 930
* CHECK dout0_24 vdout0_24ck92 = 0 time = 930
* CHECK dout0_25 vdout0_25ck92 = 1.6 time = 930
* CHECK dout0_26 vdout0_26ck92 = 0 time = 930
* CHECK dout0_27 vdout0_27ck92 = 0 time = 930
* CHECK dout0_28 vdout0_28ck92 = 1.6 time = 930
* CHECK dout0_29 vdout0_29ck92 = 0 time = 930
* CHECK dout0_30 vdout0_30ck92 = 1.6 time = 930
* CHECK dout0_31 vdout0_31ck92 = 0 time = 930
* CHECK dout0_32 vdout0_32ck92 = 0 time = 930
* CHECK dout0_0 vdout0_0ck93 = 0 time = 940
* CHECK dout0_1 vdout0_1ck93 = 1.6 time = 940
* CHECK dout0_2 vdout0_2ck93 = 0 time = 940
* CHECK dout0_3 vdout0_3ck93 = 0 time = 940
* CHECK dout0_4 vdout0_4ck93 = 1.6 time = 940
* CHECK dout0_5 vdout0_5ck93 = 1.6 time = 940
* CHECK dout0_6 vdout0_6ck93 = 0 time = 940
* CHECK dout0_7 vdout0_7ck93 = 1.6 time = 940
* CHECK dout0_8 vdout0_8ck93 = 0 time = 940
* CHECK dout0_9 vdout0_9ck93 = 1.6 time = 940
* CHECK dout0_10 vdout0_10ck93 = 1.6 time = 940
* CHECK dout0_11 vdout0_11ck93 = 1.6 time = 940
* CHECK dout0_12 vdout0_12ck93 = 1.6 time = 940
* CHECK dout0_13 vdout0_13ck93 = 0 time = 940
* CHECK dout0_14 vdout0_14ck93 = 1.6 time = 940
* CHECK dout0_15 vdout0_15ck93 = 1.6 time = 940
* CHECK dout0_16 vdout0_16ck93 = 0 time = 940
* CHECK dout0_17 vdout0_17ck93 = 0 time = 940
* CHECK dout0_18 vdout0_18ck93 = 1.6 time = 940
* CHECK dout0_19 vdout0_19ck93 = 0 time = 940
* CHECK dout0_20 vdout0_20ck93 = 0 time = 940
* CHECK dout0_21 vdout0_21ck93 = 0 time = 940
* CHECK dout0_22 vdout0_22ck93 = 1.6 time = 940
* CHECK dout0_23 vdout0_23ck93 = 1.6 time = 940
* CHECK dout0_24 vdout0_24ck93 = 0 time = 940
* CHECK dout0_25 vdout0_25ck93 = 0 time = 940
* CHECK dout0_26 vdout0_26ck93 = 0 time = 940
* CHECK dout0_27 vdout0_27ck93 = 1.6 time = 940
* CHECK dout0_28 vdout0_28ck93 = 1.6 time = 940
* CHECK dout0_29 vdout0_29ck93 = 0 time = 940
* CHECK dout0_30 vdout0_30ck93 = 1.6 time = 940
* CHECK dout0_31 vdout0_31ck93 = 0 time = 940
* CHECK dout0_32 vdout0_32ck93 = 0 time = 940
* CHECK dout0_0 vdout0_0ck94 = 0 time = 950
* CHECK dout0_1 vdout0_1ck94 = 1.6 time = 950
* CHECK dout0_2 vdout0_2ck94 = 0 time = 950
* CHECK dout0_3 vdout0_3ck94 = 0 time = 950
* CHECK dout0_4 vdout0_4ck94 = 1.6 time = 950
* CHECK dout0_5 vdout0_5ck94 = 1.6 time = 950
* CHECK dout0_6 vdout0_6ck94 = 0 time = 950
* CHECK dout0_7 vdout0_7ck94 = 1.6 time = 950
* CHECK dout0_8 vdout0_8ck94 = 0 time = 950
* CHECK dout0_9 vdout0_9ck94 = 1.6 time = 950
* CHECK dout0_10 vdout0_10ck94 = 1.6 time = 950
* CHECK dout0_11 vdout0_11ck94 = 1.6 time = 950
* CHECK dout0_12 vdout0_12ck94 = 1.6 time = 950
* CHECK dout0_13 vdout0_13ck94 = 0 time = 950
* CHECK dout0_14 vdout0_14ck94 = 1.6 time = 950
* CHECK dout0_15 vdout0_15ck94 = 1.6 time = 950
* CHECK dout0_16 vdout0_16ck94 = 0 time = 950
* CHECK dout0_17 vdout0_17ck94 = 0 time = 950
* CHECK dout0_18 vdout0_18ck94 = 1.6 time = 950
* CHECK dout0_19 vdout0_19ck94 = 0 time = 950
* CHECK dout0_20 vdout0_20ck94 = 0 time = 950
* CHECK dout0_21 vdout0_21ck94 = 0 time = 950
* CHECK dout0_22 vdout0_22ck94 = 1.6 time = 950
* CHECK dout0_23 vdout0_23ck94 = 1.6 time = 950
* CHECK dout0_24 vdout0_24ck94 = 0 time = 950
* CHECK dout0_25 vdout0_25ck94 = 0 time = 950
* CHECK dout0_26 vdout0_26ck94 = 0 time = 950
* CHECK dout0_27 vdout0_27ck94 = 1.6 time = 950
* CHECK dout0_28 vdout0_28ck94 = 1.6 time = 950
* CHECK dout0_29 vdout0_29ck94 = 0 time = 950
* CHECK dout0_30 vdout0_30ck94 = 1.6 time = 950
* CHECK dout0_31 vdout0_31ck94 = 0 time = 950
* CHECK dout0_32 vdout0_32ck94 = 0 time = 950
* CHECK dout1_0 vdout1_0ck94 = 1.6 time = 950
* CHECK dout1_1 vdout1_1ck94 = 1.6 time = 950
* CHECK dout1_2 vdout1_2ck94 = 1.6 time = 950
* CHECK dout1_3 vdout1_3ck94 = 0 time = 950
* CHECK dout1_4 vdout1_4ck94 = 0 time = 950
* CHECK dout1_5 vdout1_5ck94 = 0 time = 950
* CHECK dout1_6 vdout1_6ck94 = 0 time = 950
* CHECK dout1_7 vdout1_7ck94 = 1.6 time = 950
* CHECK dout1_8 vdout1_8ck94 = 0 time = 950
* CHECK dout1_9 vdout1_9ck94 = 0 time = 950
* CHECK dout1_10 vdout1_10ck94 = 1.6 time = 950
* CHECK dout1_11 vdout1_11ck94 = 1.6 time = 950
* CHECK dout1_12 vdout1_12ck94 = 0 time = 950
* CHECK dout1_13 vdout1_13ck94 = 1.6 time = 950
* CHECK dout1_14 vdout1_14ck94 = 0 time = 950
* CHECK dout1_15 vdout1_15ck94 = 1.6 time = 950
* CHECK dout1_16 vdout1_16ck94 = 1.6 time = 950
* CHECK dout1_17 vdout1_17ck94 = 0 time = 950
* CHECK dout1_18 vdout1_18ck94 = 1.6 time = 950
* CHECK dout1_19 vdout1_19ck94 = 1.6 time = 950
* CHECK dout1_20 vdout1_20ck94 = 1.6 time = 950
* CHECK dout1_21 vdout1_21ck94 = 1.6 time = 950
* CHECK dout1_22 vdout1_22ck94 = 1.6 time = 950
* CHECK dout1_23 vdout1_23ck94 = 1.6 time = 950
* CHECK dout1_24 vdout1_24ck94 = 0 time = 950
* CHECK dout1_25 vdout1_25ck94 = 1.6 time = 950
* CHECK dout1_26 vdout1_26ck94 = 0 time = 950
* CHECK dout1_27 vdout1_27ck94 = 0 time = 950
* CHECK dout1_28 vdout1_28ck94 = 1.6 time = 950
* CHECK dout1_29 vdout1_29ck94 = 0 time = 950
* CHECK dout1_30 vdout1_30ck94 = 1.6 time = 950
* CHECK dout1_31 vdout1_31ck94 = 0 time = 950
* CHECK dout1_32 vdout1_32ck94 = 0 time = 950
* CHECK dout0_0 vdout0_0ck95 = 1.6 time = 960
* CHECK dout0_1 vdout0_1ck95 = 0 time = 960
* CHECK dout0_2 vdout0_2ck95 = 1.6 time = 960
* CHECK dout0_3 vdout0_3ck95 = 1.6 time = 960
* CHECK dout0_4 vdout0_4ck95 = 0 time = 960
* CHECK dout0_5 vdout0_5ck95 = 1.6 time = 960
* CHECK dout0_6 vdout0_6ck95 = 1.6 time = 960
* CHECK dout0_7 vdout0_7ck95 = 0 time = 960
* CHECK dout0_8 vdout0_8ck95 = 0 time = 960
* CHECK dout0_9 vdout0_9ck95 = 0 time = 960
* CHECK dout0_10 vdout0_10ck95 = 0 time = 960
* CHECK dout0_11 vdout0_11ck95 = 1.6 time = 960
* CHECK dout0_12 vdout0_12ck95 = 0 time = 960
* CHECK dout0_13 vdout0_13ck95 = 1.6 time = 960
* CHECK dout0_14 vdout0_14ck95 = 0 time = 960
* CHECK dout0_15 vdout0_15ck95 = 0 time = 960
* CHECK dout0_16 vdout0_16ck95 = 0 time = 960
* CHECK dout0_17 vdout0_17ck95 = 0 time = 960
* CHECK dout0_18 vdout0_18ck95 = 0 time = 960
* CHECK dout0_19 vdout0_19ck95 = 1.6 time = 960
* CHECK dout0_20 vdout0_20ck95 = 1.6 time = 960
* CHECK dout0_21 vdout0_21ck95 = 1.6 time = 960
* CHECK dout0_22 vdout0_22ck95 = 1.6 time = 960
* CHECK dout0_23 vdout0_23ck95 = 1.6 time = 960
* CHECK dout0_24 vdout0_24ck95 = 0 time = 960
* CHECK dout0_25 vdout0_25ck95 = 1.6 time = 960
* CHECK dout0_26 vdout0_26ck95 = 0 time = 960
* CHECK dout0_27 vdout0_27ck95 = 0 time = 960
* CHECK dout0_28 vdout0_28ck95 = 1.6 time = 960
* CHECK dout0_29 vdout0_29ck95 = 0 time = 960
* CHECK dout0_30 vdout0_30ck95 = 1.6 time = 960
* CHECK dout0_31 vdout0_31ck95 = 0 time = 960
* CHECK dout0_32 vdout0_32ck95 = 0 time = 960
* CHECK dout1_0 vdout1_0ck96 = 1.6 time = 970
* CHECK dout1_1 vdout1_1ck96 = 0 time = 970
* CHECK dout1_2 vdout1_2ck96 = 1.6 time = 970
* CHECK dout1_3 vdout1_3ck96 = 1.6 time = 970
* CHECK dout1_4 vdout1_4ck96 = 0 time = 970
* CHECK dout1_5 vdout1_5ck96 = 1.6 time = 970
* CHECK dout1_6 vdout1_6ck96 = 1.6 time = 970
* CHECK dout1_7 vdout1_7ck96 = 0 time = 970
* CHECK dout1_8 vdout1_8ck96 = 0 time = 970
* CHECK dout1_9 vdout1_9ck96 = 0 time = 970
* CHECK dout1_10 vdout1_10ck96 = 0 time = 970
* CHECK dout1_11 vdout1_11ck96 = 1.6 time = 970
* CHECK dout1_12 vdout1_12ck96 = 0 time = 970
* CHECK dout1_13 vdout1_13ck96 = 1.6 time = 970
* CHECK dout1_14 vdout1_14ck96 = 0 time = 970
* CHECK dout1_15 vdout1_15ck96 = 0 time = 970
* CHECK dout1_16 vdout1_16ck96 = 0 time = 970
* CHECK dout1_17 vdout1_17ck96 = 0 time = 970
* CHECK dout1_18 vdout1_18ck96 = 0 time = 970
* CHECK dout1_19 vdout1_19ck96 = 1.6 time = 970
* CHECK dout1_20 vdout1_20ck96 = 1.6 time = 970
* CHECK dout1_21 vdout1_21ck96 = 1.6 time = 970
* CHECK dout1_22 vdout1_22ck96 = 1.6 time = 970
* CHECK dout1_23 vdout1_23ck96 = 1.6 time = 970
* CHECK dout1_24 vdout1_24ck96 = 0 time = 970
* CHECK dout1_25 vdout1_25ck96 = 1.6 time = 970
* CHECK dout1_26 vdout1_26ck96 = 0 time = 970
* CHECK dout1_27 vdout1_27ck96 = 0 time = 970
* CHECK dout1_28 vdout1_28ck96 = 1.6 time = 970
* CHECK dout1_29 vdout1_29ck96 = 0 time = 970
* CHECK dout1_30 vdout1_30ck96 = 1.6 time = 970
* CHECK dout1_31 vdout1_31ck96 = 0 time = 970
* CHECK dout1_32 vdout1_32ck96 = 0 time = 970
* CHECK dout0_0 vdout0_0ck97 = 1.6 time = 980
* CHECK dout0_1 vdout0_1ck97 = 0 time = 980
* CHECK dout0_2 vdout0_2ck97 = 1.6 time = 980
* CHECK dout0_3 vdout0_3ck97 = 1.6 time = 980
* CHECK dout0_4 vdout0_4ck97 = 0 time = 980
* CHECK dout0_5 vdout0_5ck97 = 1.6 time = 980
* CHECK dout0_6 vdout0_6ck97 = 1.6 time = 980
* CHECK dout0_7 vdout0_7ck97 = 0 time = 980
* CHECK dout0_8 vdout0_8ck97 = 0 time = 980
* CHECK dout0_9 vdout0_9ck97 = 0 time = 980
* CHECK dout0_10 vdout0_10ck97 = 0 time = 980
* CHECK dout0_11 vdout0_11ck97 = 1.6 time = 980
* CHECK dout0_12 vdout0_12ck97 = 0 time = 980
* CHECK dout0_13 vdout0_13ck97 = 1.6 time = 980
* CHECK dout0_14 vdout0_14ck97 = 0 time = 980
* CHECK dout0_15 vdout0_15ck97 = 0 time = 980
* CHECK dout0_16 vdout0_16ck97 = 0 time = 980
* CHECK dout0_17 vdout0_17ck97 = 0 time = 980
* CHECK dout0_18 vdout0_18ck97 = 0 time = 980
* CHECK dout0_19 vdout0_19ck97 = 1.6 time = 980
* CHECK dout0_20 vdout0_20ck97 = 1.6 time = 980
* CHECK dout0_21 vdout0_21ck97 = 1.6 time = 980
* CHECK dout0_22 vdout0_22ck97 = 1.6 time = 980
* CHECK dout0_23 vdout0_23ck97 = 1.6 time = 980
* CHECK dout0_24 vdout0_24ck97 = 0 time = 980
* CHECK dout0_25 vdout0_25ck97 = 1.6 time = 980
* CHECK dout0_26 vdout0_26ck97 = 0 time = 980
* CHECK dout0_27 vdout0_27ck97 = 0 time = 980
* CHECK dout0_28 vdout0_28ck97 = 1.6 time = 980
* CHECK dout0_29 vdout0_29ck97 = 0 time = 980
* CHECK dout0_30 vdout0_30ck97 = 1.6 time = 980
* CHECK dout0_31 vdout0_31ck97 = 0 time = 980
* CHECK dout0_32 vdout0_32ck97 = 0 time = 980
* CHECK dout1_0 vdout1_0ck97 = 1.6 time = 980
* CHECK dout1_1 vdout1_1ck97 = 1.6 time = 980
* CHECK dout1_2 vdout1_2ck97 = 1.6 time = 980
* CHECK dout1_3 vdout1_3ck97 = 0 time = 980
* CHECK dout1_4 vdout1_4ck97 = 0 time = 980
* CHECK dout1_5 vdout1_5ck97 = 1.6 time = 980
* CHECK dout1_6 vdout1_6ck97 = 1.6 time = 980
* CHECK dout1_7 vdout1_7ck97 = 1.6 time = 980
* CHECK dout1_8 vdout1_8ck97 = 1.6 time = 980
* CHECK dout1_9 vdout1_9ck97 = 1.6 time = 980
* CHECK dout1_10 vdout1_10ck97 = 1.6 time = 980
* CHECK dout1_11 vdout1_11ck97 = 1.6 time = 980
* CHECK dout1_12 vdout1_12ck97 = 1.6 time = 980
* CHECK dout1_13 vdout1_13ck97 = 1.6 time = 980
* CHECK dout1_14 vdout1_14ck97 = 1.6 time = 980
* CHECK dout1_15 vdout1_15ck97 = 0 time = 980
* CHECK dout1_16 vdout1_16ck97 = 0 time = 980
* CHECK dout1_17 vdout1_17ck97 = 1.6 time = 980
* CHECK dout1_18 vdout1_18ck97 = 1.6 time = 980
* CHECK dout1_19 vdout1_19ck97 = 0 time = 980
* CHECK dout1_20 vdout1_20ck97 = 1.6 time = 980
* CHECK dout1_21 vdout1_21ck97 = 1.6 time = 980
* CHECK dout1_22 vdout1_22ck97 = 0 time = 980
* CHECK dout1_23 vdout1_23ck97 = 0 time = 980
* CHECK dout1_24 vdout1_24ck97 = 1.6 time = 980
* CHECK dout1_25 vdout1_25ck97 = 1.6 time = 980
* CHECK dout1_26 vdout1_26ck97 = 0 time = 980
* CHECK dout1_27 vdout1_27ck97 = 0 time = 980
* CHECK dout1_28 vdout1_28ck97 = 0 time = 980
* CHECK dout1_29 vdout1_29ck97 = 1.6 time = 980
* CHECK dout1_30 vdout1_30ck97 = 0 time = 980
* CHECK dout1_31 vdout1_31ck97 = 0 time = 980
* CHECK dout1_32 vdout1_32ck97 = 0 time = 980
* CHECK dout0_0 vdout0_0ck99 = 1.6 time = 1000
* CHECK dout0_1 vdout0_1ck99 = 1.6 time = 1000
* CHECK dout0_2 vdout0_2ck99 = 1.6 time = 1000
* CHECK dout0_3 vdout0_3ck99 = 0 time = 1000
* CHECK dout0_4 vdout0_4ck99 = 0 time = 1000
* CHECK dout0_5 vdout0_5ck99 = 0 time = 1000
* CHECK dout0_6 vdout0_6ck99 = 0 time = 1000
* CHECK dout0_7 vdout0_7ck99 = 1.6 time = 1000
* CHECK dout0_8 vdout0_8ck99 = 0 time = 1000
* CHECK dout0_9 vdout0_9ck99 = 0 time = 1000
* CHECK dout0_10 vdout0_10ck99 = 1.6 time = 1000
* CHECK dout0_11 vdout0_11ck99 = 1.6 time = 1000
* CHECK dout0_12 vdout0_12ck99 = 0 time = 1000
* CHECK dout0_13 vdout0_13ck99 = 1.6 time = 1000
* CHECK dout0_14 vdout0_14ck99 = 0 time = 1000
* CHECK dout0_15 vdout0_15ck99 = 1.6 time = 1000
* CHECK dout0_16 vdout0_16ck99 = 1.6 time = 1000
* CHECK dout0_17 vdout0_17ck99 = 0 time = 1000
* CHECK dout0_18 vdout0_18ck99 = 1.6 time = 1000
* CHECK dout0_19 vdout0_19ck99 = 1.6 time = 1000
* CHECK dout0_20 vdout0_20ck99 = 1.6 time = 1000
* CHECK dout0_21 vdout0_21ck99 = 1.6 time = 1000
* CHECK dout0_22 vdout0_22ck99 = 1.6 time = 1000
* CHECK dout0_23 vdout0_23ck99 = 1.6 time = 1000
* CHECK dout0_24 vdout0_24ck99 = 0 time = 1000
* CHECK dout0_25 vdout0_25ck99 = 1.6 time = 1000
* CHECK dout0_26 vdout0_26ck99 = 0 time = 1000
* CHECK dout0_27 vdout0_27ck99 = 0 time = 1000
* CHECK dout0_28 vdout0_28ck99 = 1.6 time = 1000
* CHECK dout0_29 vdout0_29ck99 = 0 time = 1000
* CHECK dout0_30 vdout0_30ck99 = 1.6 time = 1000
* CHECK dout0_31 vdout0_31ck99 = 0 time = 1000
* CHECK dout0_32 vdout0_32ck99 = 0 time = 1000
* CHECK dout1_0 vdout1_0ck99 = 1.6 time = 1000
* CHECK dout1_1 vdout1_1ck99 = 1.6 time = 1000
* CHECK dout1_2 vdout1_2ck99 = 1.6 time = 1000
* CHECK dout1_3 vdout1_3ck99 = 1.6 time = 1000
* CHECK dout1_4 vdout1_4ck99 = 1.6 time = 1000
* CHECK dout1_5 vdout1_5ck99 = 0 time = 1000
* CHECK dout1_6 vdout1_6ck99 = 0 time = 1000
* CHECK dout1_7 vdout1_7ck99 = 1.6 time = 1000
* CHECK dout1_8 vdout1_8ck99 = 1.6 time = 1000
* CHECK dout1_9 vdout1_9ck99 = 0 time = 1000
* CHECK dout1_10 vdout1_10ck99 = 0 time = 1000
* CHECK dout1_11 vdout1_11ck99 = 1.6 time = 1000
* CHECK dout1_12 vdout1_12ck99 = 0 time = 1000
* CHECK dout1_13 vdout1_13ck99 = 0 time = 1000
* CHECK dout1_14 vdout1_14ck99 = 0 time = 1000
* CHECK dout1_15 vdout1_15ck99 = 0 time = 1000
* CHECK dout1_16 vdout1_16ck99 = 1.6 time = 1000
* CHECK dout1_17 vdout1_17ck99 = 1.6 time = 1000
* CHECK dout1_18 vdout1_18ck99 = 1.6 time = 1000
* CHECK dout1_19 vdout1_19ck99 = 0 time = 1000
* CHECK dout1_20 vdout1_20ck99 = 0 time = 1000
* CHECK dout1_21 vdout1_21ck99 = 0 time = 1000
* CHECK dout1_22 vdout1_22ck99 = 1.6 time = 1000
* CHECK dout1_23 vdout1_23ck99 = 0 time = 1000
* CHECK dout1_24 vdout1_24ck99 = 1.6 time = 1000
* CHECK dout1_25 vdout1_25ck99 = 1.6 time = 1000
* CHECK dout1_26 vdout1_26ck99 = 1.6 time = 1000
* CHECK dout1_27 vdout1_27ck99 = 0 time = 1000
* CHECK dout1_28 vdout1_28ck99 = 1.6 time = 1000
* CHECK dout1_29 vdout1_29ck99 = 0 time = 1000
* CHECK dout1_30 vdout1_30ck99 = 1.6 time = 1000
* CHECK dout1_31 vdout1_31ck99 = 1.6 time = 1000
* CHECK dout1_32 vdout1_32ck99 = 0 time = 1000
* CHECK dout0_0 vdout0_0ck102 = 1.6 time = 1030
* CHECK dout0_1 vdout0_1ck102 = 0 time = 1030
* CHECK dout0_2 vdout0_2ck102 = 0 time = 1030
* CHECK dout0_3 vdout0_3ck102 = 1.6 time = 1030
* CHECK dout0_4 vdout0_4ck102 = 0 time = 1030
* CHECK dout0_5 vdout0_5ck102 = 1.6 time = 1030
* CHECK dout0_6 vdout0_6ck102 = 0 time = 1030
* CHECK dout0_7 vdout0_7ck102 = 1.6 time = 1030
* CHECK dout0_8 vdout0_8ck102 = 0 time = 1030
* CHECK dout0_9 vdout0_9ck102 = 0 time = 1030
* CHECK dout0_10 vdout0_10ck102 = 0 time = 1030
* CHECK dout0_11 vdout0_11ck102 = 1.6 time = 1030
* CHECK dout0_12 vdout0_12ck102 = 0 time = 1030
* CHECK dout0_13 vdout0_13ck102 = 1.6 time = 1030
* CHECK dout0_14 vdout0_14ck102 = 0 time = 1030
* CHECK dout0_15 vdout0_15ck102 = 1.6 time = 1030
* CHECK dout0_16 vdout0_16ck102 = 1.6 time = 1030
* CHECK dout0_17 vdout0_17ck102 = 1.6 time = 1030
* CHECK dout0_18 vdout0_18ck102 = 0 time = 1030
* CHECK dout0_19 vdout0_19ck102 = 0 time = 1030
* CHECK dout0_20 vdout0_20ck102 = 1.6 time = 1030
* CHECK dout0_21 vdout0_21ck102 = 1.6 time = 1030
* CHECK dout0_22 vdout0_22ck102 = 0 time = 1030
* CHECK dout0_23 vdout0_23ck102 = 0 time = 1030
* CHECK dout0_24 vdout0_24ck102 = 1.6 time = 1030
* CHECK dout0_25 vdout0_25ck102 = 1.6 time = 1030
* CHECK dout0_26 vdout0_26ck102 = 1.6 time = 1030
* CHECK dout0_27 vdout0_27ck102 = 1.6 time = 1030
* CHECK dout0_28 vdout0_28ck102 = 0 time = 1030
* CHECK dout0_29 vdout0_29ck102 = 1.6 time = 1030
* CHECK dout0_30 vdout0_30ck102 = 0 time = 1030
* CHECK dout0_31 vdout0_31ck102 = 0 time = 1030
* CHECK dout0_32 vdout0_32ck102 = 0 time = 1030
* CHECK dout1_0 vdout1_0ck102 = 1.6 time = 1030
* CHECK dout1_1 vdout1_1ck102 = 0 time = 1030
* CHECK dout1_2 vdout1_2ck102 = 1.6 time = 1030
* CHECK dout1_3 vdout1_3ck102 = 1.6 time = 1030
* CHECK dout1_4 vdout1_4ck102 = 0 time = 1030
* CHECK dout1_5 vdout1_5ck102 = 1.6 time = 1030
* CHECK dout1_6 vdout1_6ck102 = 1.6 time = 1030
* CHECK dout1_7 vdout1_7ck102 = 0 time = 1030
* CHECK dout1_8 vdout1_8ck102 = 0 time = 1030
* CHECK dout1_9 vdout1_9ck102 = 0 time = 1030
* CHECK dout1_10 vdout1_10ck102 = 0 time = 1030
* CHECK dout1_11 vdout1_11ck102 = 1.6 time = 1030
* CHECK dout1_12 vdout1_12ck102 = 0 time = 1030
* CHECK dout1_13 vdout1_13ck102 = 1.6 time = 1030
* CHECK dout1_14 vdout1_14ck102 = 0 time = 1030
* CHECK dout1_15 vdout1_15ck102 = 0 time = 1030
* CHECK dout1_16 vdout1_16ck102 = 0 time = 1030
* CHECK dout1_17 vdout1_17ck102 = 0 time = 1030
* CHECK dout1_18 vdout1_18ck102 = 0 time = 1030
* CHECK dout1_19 vdout1_19ck102 = 1.6 time = 1030
* CHECK dout1_20 vdout1_20ck102 = 1.6 time = 1030
* CHECK dout1_21 vdout1_21ck102 = 1.6 time = 1030
* CHECK dout1_22 vdout1_22ck102 = 1.6 time = 1030
* CHECK dout1_23 vdout1_23ck102 = 1.6 time = 1030
* CHECK dout1_24 vdout1_24ck102 = 0 time = 1030
* CHECK dout1_25 vdout1_25ck102 = 1.6 time = 1030
* CHECK dout1_26 vdout1_26ck102 = 0 time = 1030
* CHECK dout1_27 vdout1_27ck102 = 0 time = 1030
* CHECK dout1_28 vdout1_28ck102 = 1.6 time = 1030
* CHECK dout1_29 vdout1_29ck102 = 0 time = 1030
* CHECK dout1_30 vdout1_30ck102 = 1.6 time = 1030
* CHECK dout1_31 vdout1_31ck102 = 0 time = 1030
* CHECK dout1_32 vdout1_32ck102 = 0 time = 1030
* CHECK dout0_0 vdout0_0ck103 = 1.6 time = 1040
* CHECK dout0_1 vdout0_1ck103 = 0 time = 1040
* CHECK dout0_2 vdout0_2ck103 = 0 time = 1040
* CHECK dout0_3 vdout0_3ck103 = 1.6 time = 1040
* CHECK dout0_4 vdout0_4ck103 = 0 time = 1040
* CHECK dout0_5 vdout0_5ck103 = 1.6 time = 1040
* CHECK dout0_6 vdout0_6ck103 = 0 time = 1040
* CHECK dout0_7 vdout0_7ck103 = 1.6 time = 1040
* CHECK dout0_8 vdout0_8ck103 = 0 time = 1040
* CHECK dout0_9 vdout0_9ck103 = 0 time = 1040
* CHECK dout0_10 vdout0_10ck103 = 0 time = 1040
* CHECK dout0_11 vdout0_11ck103 = 1.6 time = 1040
* CHECK dout0_12 vdout0_12ck103 = 0 time = 1040
* CHECK dout0_13 vdout0_13ck103 = 1.6 time = 1040
* CHECK dout0_14 vdout0_14ck103 = 0 time = 1040
* CHECK dout0_15 vdout0_15ck103 = 1.6 time = 1040
* CHECK dout0_16 vdout0_16ck103 = 1.6 time = 1040
* CHECK dout0_17 vdout0_17ck103 = 1.6 time = 1040
* CHECK dout0_18 vdout0_18ck103 = 0 time = 1040
* CHECK dout0_19 vdout0_19ck103 = 0 time = 1040
* CHECK dout0_20 vdout0_20ck103 = 1.6 time = 1040
* CHECK dout0_21 vdout0_21ck103 = 1.6 time = 1040
* CHECK dout0_22 vdout0_22ck103 = 0 time = 1040
* CHECK dout0_23 vdout0_23ck103 = 0 time = 1040
* CHECK dout0_24 vdout0_24ck103 = 1.6 time = 1040
* CHECK dout0_25 vdout0_25ck103 = 1.6 time = 1040
* CHECK dout0_26 vdout0_26ck103 = 1.6 time = 1040
* CHECK dout0_27 vdout0_27ck103 = 1.6 time = 1040
* CHECK dout0_28 vdout0_28ck103 = 0 time = 1040
* CHECK dout0_29 vdout0_29ck103 = 1.6 time = 1040
* CHECK dout0_30 vdout0_30ck103 = 0 time = 1040
* CHECK dout0_31 vdout0_31ck103 = 0 time = 1040
* CHECK dout0_32 vdout0_32ck103 = 0 time = 1040
* CHECK dout1_0 vdout1_0ck103 = 1.6 time = 1040
* CHECK dout1_1 vdout1_1ck103 = 0 time = 1040
* CHECK dout1_2 vdout1_2ck103 = 1.6 time = 1040
* CHECK dout1_3 vdout1_3ck103 = 1.6 time = 1040
* CHECK dout1_4 vdout1_4ck103 = 0 time = 1040
* CHECK dout1_5 vdout1_5ck103 = 1.6 time = 1040
* CHECK dout1_6 vdout1_6ck103 = 1.6 time = 1040
* CHECK dout1_7 vdout1_7ck103 = 0 time = 1040
* CHECK dout1_8 vdout1_8ck103 = 0 time = 1040
* CHECK dout1_9 vdout1_9ck103 = 0 time = 1040
* CHECK dout1_10 vdout1_10ck103 = 0 time = 1040
* CHECK dout1_11 vdout1_11ck103 = 1.6 time = 1040
* CHECK dout1_12 vdout1_12ck103 = 0 time = 1040
* CHECK dout1_13 vdout1_13ck103 = 1.6 time = 1040
* CHECK dout1_14 vdout1_14ck103 = 0 time = 1040
* CHECK dout1_15 vdout1_15ck103 = 0 time = 1040
* CHECK dout1_16 vdout1_16ck103 = 0 time = 1040
* CHECK dout1_17 vdout1_17ck103 = 0 time = 1040
* CHECK dout1_18 vdout1_18ck103 = 0 time = 1040
* CHECK dout1_19 vdout1_19ck103 = 1.6 time = 1040
* CHECK dout1_20 vdout1_20ck103 = 1.6 time = 1040
* CHECK dout1_21 vdout1_21ck103 = 1.6 time = 1040
* CHECK dout1_22 vdout1_22ck103 = 1.6 time = 1040
* CHECK dout1_23 vdout1_23ck103 = 1.6 time = 1040
* CHECK dout1_24 vdout1_24ck103 = 0 time = 1040
* CHECK dout1_25 vdout1_25ck103 = 1.6 time = 1040
* CHECK dout1_26 vdout1_26ck103 = 0 time = 1040
* CHECK dout1_27 vdout1_27ck103 = 0 time = 1040
* CHECK dout1_28 vdout1_28ck103 = 1.6 time = 1040
* CHECK dout1_29 vdout1_29ck103 = 0 time = 1040
* CHECK dout1_30 vdout1_30ck103 = 1.6 time = 1040
* CHECK dout1_31 vdout1_31ck103 = 0 time = 1040
* CHECK dout1_32 vdout1_32ck103 = 0 time = 1040
* CHECK dout0_0 vdout0_0ck105 = 1.6 time = 1060
* CHECK dout0_1 vdout0_1ck105 = 0 time = 1060
* CHECK dout0_2 vdout0_2ck105 = 0 time = 1060
* CHECK dout0_3 vdout0_3ck105 = 1.6 time = 1060
* CHECK dout0_4 vdout0_4ck105 = 0 time = 1060
* CHECK dout0_5 vdout0_5ck105 = 1.6 time = 1060
* CHECK dout0_6 vdout0_6ck105 = 0 time = 1060
* CHECK dout0_7 vdout0_7ck105 = 1.6 time = 1060
* CHECK dout0_8 vdout0_8ck105 = 0 time = 1060
* CHECK dout0_9 vdout0_9ck105 = 0 time = 1060
* CHECK dout0_10 vdout0_10ck105 = 0 time = 1060
* CHECK dout0_11 vdout0_11ck105 = 1.6 time = 1060
* CHECK dout0_12 vdout0_12ck105 = 0 time = 1060
* CHECK dout0_13 vdout0_13ck105 = 1.6 time = 1060
* CHECK dout0_14 vdout0_14ck105 = 0 time = 1060
* CHECK dout0_15 vdout0_15ck105 = 1.6 time = 1060
* CHECK dout0_16 vdout0_16ck105 = 1.6 time = 1060
* CHECK dout0_17 vdout0_17ck105 = 1.6 time = 1060
* CHECK dout0_18 vdout0_18ck105 = 0 time = 1060
* CHECK dout0_19 vdout0_19ck105 = 0 time = 1060
* CHECK dout0_20 vdout0_20ck105 = 1.6 time = 1060
* CHECK dout0_21 vdout0_21ck105 = 1.6 time = 1060
* CHECK dout0_22 vdout0_22ck105 = 0 time = 1060
* CHECK dout0_23 vdout0_23ck105 = 0 time = 1060
* CHECK dout0_24 vdout0_24ck105 = 1.6 time = 1060
* CHECK dout0_25 vdout0_25ck105 = 1.6 time = 1060
* CHECK dout0_26 vdout0_26ck105 = 1.6 time = 1060
* CHECK dout0_27 vdout0_27ck105 = 1.6 time = 1060
* CHECK dout0_28 vdout0_28ck105 = 0 time = 1060
* CHECK dout0_29 vdout0_29ck105 = 1.6 time = 1060
* CHECK dout0_30 vdout0_30ck105 = 0 time = 1060
* CHECK dout0_31 vdout0_31ck105 = 0 time = 1060
* CHECK dout0_32 vdout0_32ck105 = 0 time = 1060
* CHECK dout0_0 vdout0_0ck106 = 1.6 time = 1070
* CHECK dout0_1 vdout0_1ck106 = 1.6 time = 1070
* CHECK dout0_2 vdout0_2ck106 = 1.6 time = 1070
* CHECK dout0_3 vdout0_3ck106 = 0 time = 1070
* CHECK dout0_4 vdout0_4ck106 = 0 time = 1070
* CHECK dout0_5 vdout0_5ck106 = 1.6 time = 1070
* CHECK dout0_6 vdout0_6ck106 = 1.6 time = 1070
* CHECK dout0_7 vdout0_7ck106 = 1.6 time = 1070
* CHECK dout0_8 vdout0_8ck106 = 1.6 time = 1070
* CHECK dout0_9 vdout0_9ck106 = 1.6 time = 1070
* CHECK dout0_10 vdout0_10ck106 = 1.6 time = 1070
* CHECK dout0_11 vdout0_11ck106 = 1.6 time = 1070
* CHECK dout0_12 vdout0_12ck106 = 1.6 time = 1070
* CHECK dout0_13 vdout0_13ck106 = 1.6 time = 1070
* CHECK dout0_14 vdout0_14ck106 = 1.6 time = 1070
* CHECK dout0_15 vdout0_15ck106 = 0 time = 1070
* CHECK dout0_16 vdout0_16ck106 = 0 time = 1070
* CHECK dout0_17 vdout0_17ck106 = 1.6 time = 1070
* CHECK dout0_18 vdout0_18ck106 = 1.6 time = 1070
* CHECK dout0_19 vdout0_19ck106 = 0 time = 1070
* CHECK dout0_20 vdout0_20ck106 = 1.6 time = 1070
* CHECK dout0_21 vdout0_21ck106 = 1.6 time = 1070
* CHECK dout0_22 vdout0_22ck106 = 0 time = 1070
* CHECK dout0_23 vdout0_23ck106 = 0 time = 1070
* CHECK dout0_24 vdout0_24ck106 = 1.6 time = 1070
* CHECK dout0_25 vdout0_25ck106 = 1.6 time = 1070
* CHECK dout0_26 vdout0_26ck106 = 0 time = 1070
* CHECK dout0_27 vdout0_27ck106 = 0 time = 1070
* CHECK dout0_28 vdout0_28ck106 = 0 time = 1070
* CHECK dout0_29 vdout0_29ck106 = 1.6 time = 1070
* CHECK dout0_30 vdout0_30ck106 = 0 time = 1070
* CHECK dout0_31 vdout0_31ck106 = 0 time = 1070
* CHECK dout0_32 vdout0_32ck106 = 0 time = 1070
* CHECK dout0_0 vdout0_0ck107 = 0 time = 1080
* CHECK dout0_1 vdout0_1ck107 = 1.6 time = 1080
* CHECK dout0_2 vdout0_2ck107 = 1.6 time = 1080
* CHECK dout0_3 vdout0_3ck107 = 1.6 time = 1080
* CHECK dout0_4 vdout0_4ck107 = 0 time = 1080
* CHECK dout0_5 vdout0_5ck107 = 0 time = 1080
* CHECK dout0_6 vdout0_6ck107 = 1.6 time = 1080
* CHECK dout0_7 vdout0_7ck107 = 1.6 time = 1080
* CHECK dout0_8 vdout0_8ck107 = 1.6 time = 1080
* CHECK dout0_9 vdout0_9ck107 = 0 time = 1080
* CHECK dout0_10 vdout0_10ck107 = 0 time = 1080
* CHECK dout0_11 vdout0_11ck107 = 0 time = 1080
* CHECK dout0_12 vdout0_12ck107 = 1.6 time = 1080
* CHECK dout0_13 vdout0_13ck107 = 1.6 time = 1080
* CHECK dout0_14 vdout0_14ck107 = 0 time = 1080
* CHECK dout0_15 vdout0_15ck107 = 0 time = 1080
* CHECK dout0_16 vdout0_16ck107 = 1.6 time = 1080
* CHECK dout0_17 vdout0_17ck107 = 0 time = 1080
* CHECK dout0_18 vdout0_18ck107 = 1.6 time = 1080
* CHECK dout0_19 vdout0_19ck107 = 1.6 time = 1080
* CHECK dout0_20 vdout0_20ck107 = 1.6 time = 1080
* CHECK dout0_21 vdout0_21ck107 = 0 time = 1080
* CHECK dout0_22 vdout0_22ck107 = 0 time = 1080
* CHECK dout0_23 vdout0_23ck107 = 1.6 time = 1080
* CHECK dout0_24 vdout0_24ck107 = 0 time = 1080
* CHECK dout0_25 vdout0_25ck107 = 1.6 time = 1080
* CHECK dout0_26 vdout0_26ck107 = 1.6 time = 1080
* CHECK dout0_27 vdout0_27ck107 = 0 time = 1080
* CHECK dout0_28 vdout0_28ck107 = 0 time = 1080
* CHECK dout0_29 vdout0_29ck107 = 0 time = 1080
* CHECK dout0_30 vdout0_30ck107 = 1.6 time = 1080
* CHECK dout0_31 vdout0_31ck107 = 1.6 time = 1080
* CHECK dout0_32 vdout0_32ck107 = 0 time = 1080
* CHECK dout1_0 vdout1_0ck107 = 1.6 time = 1080
* CHECK dout1_1 vdout1_1ck107 = 1.6 time = 1080
* CHECK dout1_2 vdout1_2ck107 = 1.6 time = 1080
* CHECK dout1_3 vdout1_3ck107 = 1.6 time = 1080
* CHECK dout1_4 vdout1_4ck107 = 1.6 time = 1080
* CHECK dout1_5 vdout1_5ck107 = 0 time = 1080
* CHECK dout1_6 vdout1_6ck107 = 0 time = 1080
* CHECK dout1_7 vdout1_7ck107 = 1.6 time = 1080
* CHECK dout1_8 vdout1_8ck107 = 1.6 time = 1080
* CHECK dout1_9 vdout1_9ck107 = 0 time = 1080
* CHECK dout1_10 vdout1_10ck107 = 0 time = 1080
* CHECK dout1_11 vdout1_11ck107 = 1.6 time = 1080
* CHECK dout1_12 vdout1_12ck107 = 0 time = 1080
* CHECK dout1_13 vdout1_13ck107 = 0 time = 1080
* CHECK dout1_14 vdout1_14ck107 = 0 time = 1080
* CHECK dout1_15 vdout1_15ck107 = 0 time = 1080
* CHECK dout1_16 vdout1_16ck107 = 1.6 time = 1080
* CHECK dout1_17 vdout1_17ck107 = 1.6 time = 1080
* CHECK dout1_18 vdout1_18ck107 = 1.6 time = 1080
* CHECK dout1_19 vdout1_19ck107 = 0 time = 1080
* CHECK dout1_20 vdout1_20ck107 = 0 time = 1080
* CHECK dout1_21 vdout1_21ck107 = 0 time = 1080
* CHECK dout1_22 vdout1_22ck107 = 1.6 time = 1080
* CHECK dout1_23 vdout1_23ck107 = 0 time = 1080
* CHECK dout1_24 vdout1_24ck107 = 1.6 time = 1080
* CHECK dout1_25 vdout1_25ck107 = 1.6 time = 1080
* CHECK dout1_26 vdout1_26ck107 = 1.6 time = 1080
* CHECK dout1_27 vdout1_27ck107 = 0 time = 1080
* CHECK dout1_28 vdout1_28ck107 = 1.6 time = 1080
* CHECK dout1_29 vdout1_29ck107 = 0 time = 1080
* CHECK dout1_30 vdout1_30ck107 = 1.6 time = 1080
* CHECK dout1_31 vdout1_31ck107 = 1.6 time = 1080
* CHECK dout1_32 vdout1_32ck107 = 0 time = 1080
* CHECK dout1_0 vdout1_0ck108 = 1.6 time = 1090
* CHECK dout1_1 vdout1_1ck108 = 0 time = 1090
* CHECK dout1_2 vdout1_2ck108 = 0 time = 1090
* CHECK dout1_3 vdout1_3ck108 = 1.6 time = 1090
* CHECK dout1_4 vdout1_4ck108 = 0 time = 1090
* CHECK dout1_5 vdout1_5ck108 = 1.6 time = 1090
* CHECK dout1_6 vdout1_6ck108 = 0 time = 1090
* CHECK dout1_7 vdout1_7ck108 = 1.6 time = 1090
* CHECK dout1_8 vdout1_8ck108 = 0 time = 1090
* CHECK dout1_9 vdout1_9ck108 = 0 time = 1090
* CHECK dout1_10 vdout1_10ck108 = 0 time = 1090
* CHECK dout1_11 vdout1_11ck108 = 1.6 time = 1090
* CHECK dout1_12 vdout1_12ck108 = 0 time = 1090
* CHECK dout1_13 vdout1_13ck108 = 1.6 time = 1090
* CHECK dout1_14 vdout1_14ck108 = 0 time = 1090
* CHECK dout1_15 vdout1_15ck108 = 1.6 time = 1090
* CHECK dout1_16 vdout1_16ck108 = 1.6 time = 1090
* CHECK dout1_17 vdout1_17ck108 = 1.6 time = 1090
* CHECK dout1_18 vdout1_18ck108 = 0 time = 1090
* CHECK dout1_19 vdout1_19ck108 = 0 time = 1090
* CHECK dout1_20 vdout1_20ck108 = 1.6 time = 1090
* CHECK dout1_21 vdout1_21ck108 = 1.6 time = 1090
* CHECK dout1_22 vdout1_22ck108 = 0 time = 1090
* CHECK dout1_23 vdout1_23ck108 = 0 time = 1090
* CHECK dout1_24 vdout1_24ck108 = 1.6 time = 1090
* CHECK dout1_25 vdout1_25ck108 = 1.6 time = 1090
* CHECK dout1_26 vdout1_26ck108 = 1.6 time = 1090
* CHECK dout1_27 vdout1_27ck108 = 1.6 time = 1090
* CHECK dout1_28 vdout1_28ck108 = 0 time = 1090
* CHECK dout1_29 vdout1_29ck108 = 1.6 time = 1090
* CHECK dout1_30 vdout1_30ck108 = 0 time = 1090
* CHECK dout1_31 vdout1_31ck108 = 0 time = 1090
* CHECK dout1_32 vdout1_32ck108 = 0 time = 1090
* CHECK dout0_0 vdout0_0ck109 = 1.6 time = 1100
* CHECK dout0_1 vdout0_1ck109 = 1.6 time = 1100
* CHECK dout0_2 vdout0_2ck109 = 1.6 time = 1100
* CHECK dout0_3 vdout0_3ck109 = 1.6 time = 1100
* CHECK dout0_4 vdout0_4ck109 = 1.6 time = 1100
* CHECK dout0_5 vdout0_5ck109 = 0 time = 1100
* CHECK dout0_6 vdout0_6ck109 = 0 time = 1100
* CHECK dout0_7 vdout0_7ck109 = 1.6 time = 1100
* CHECK dout0_8 vdout0_8ck109 = 1.6 time = 1100
* CHECK dout0_9 vdout0_9ck109 = 0 time = 1100
* CHECK dout0_10 vdout0_10ck109 = 0 time = 1100
* CHECK dout0_11 vdout0_11ck109 = 1.6 time = 1100
* CHECK dout0_12 vdout0_12ck109 = 0 time = 1100
* CHECK dout0_13 vdout0_13ck109 = 0 time = 1100
* CHECK dout0_14 vdout0_14ck109 = 0 time = 1100
* CHECK dout0_15 vdout0_15ck109 = 0 time = 1100
* CHECK dout0_16 vdout0_16ck109 = 1.6 time = 1100
* CHECK dout0_17 vdout0_17ck109 = 1.6 time = 1100
* CHECK dout0_18 vdout0_18ck109 = 1.6 time = 1100
* CHECK dout0_19 vdout0_19ck109 = 0 time = 1100
* CHECK dout0_20 vdout0_20ck109 = 0 time = 1100
* CHECK dout0_21 vdout0_21ck109 = 0 time = 1100
* CHECK dout0_22 vdout0_22ck109 = 1.6 time = 1100
* CHECK dout0_23 vdout0_23ck109 = 0 time = 1100
* CHECK dout0_24 vdout0_24ck109 = 1.6 time = 1100
* CHECK dout0_25 vdout0_25ck109 = 1.6 time = 1100
* CHECK dout0_26 vdout0_26ck109 = 1.6 time = 1100
* CHECK dout0_27 vdout0_27ck109 = 0 time = 1100
* CHECK dout0_28 vdout0_28ck109 = 1.6 time = 1100
* CHECK dout0_29 vdout0_29ck109 = 0 time = 1100
* CHECK dout0_30 vdout0_30ck109 = 1.6 time = 1100
* CHECK dout0_31 vdout0_31ck109 = 1.6 time = 1100
* CHECK dout0_32 vdout0_32ck109 = 0 time = 1100
* CHECK dout1_0 vdout1_0ck109 = 0 time = 1100
* CHECK dout1_1 vdout1_1ck109 = 1.6 time = 1100
* CHECK dout1_2 vdout1_2ck109 = 1.6 time = 1100
* CHECK dout1_3 vdout1_3ck109 = 1.6 time = 1100
* CHECK dout1_4 vdout1_4ck109 = 0 time = 1100
* CHECK dout1_5 vdout1_5ck109 = 0 time = 1100
* CHECK dout1_6 vdout1_6ck109 = 1.6 time = 1100
* CHECK dout1_7 vdout1_7ck109 = 1.6 time = 1100
* CHECK dout1_8 vdout1_8ck109 = 1.6 time = 1100
* CHECK dout1_9 vdout1_9ck109 = 0 time = 1100
* CHECK dout1_10 vdout1_10ck109 = 0 time = 1100
* CHECK dout1_11 vdout1_11ck109 = 0 time = 1100
* CHECK dout1_12 vdout1_12ck109 = 1.6 time = 1100
* CHECK dout1_13 vdout1_13ck109 = 1.6 time = 1100
* CHECK dout1_14 vdout1_14ck109 = 0 time = 1100
* CHECK dout1_15 vdout1_15ck109 = 0 time = 1100
* CHECK dout1_16 vdout1_16ck109 = 1.6 time = 1100
* CHECK dout1_17 vdout1_17ck109 = 0 time = 1100
* CHECK dout1_18 vdout1_18ck109 = 1.6 time = 1100
* CHECK dout1_19 vdout1_19ck109 = 1.6 time = 1100
* CHECK dout1_20 vdout1_20ck109 = 1.6 time = 1100
* CHECK dout1_21 vdout1_21ck109 = 0 time = 1100
* CHECK dout1_22 vdout1_22ck109 = 0 time = 1100
* CHECK dout1_23 vdout1_23ck109 = 1.6 time = 1100
* CHECK dout1_24 vdout1_24ck109 = 0 time = 1100
* CHECK dout1_25 vdout1_25ck109 = 1.6 time = 1100
* CHECK dout1_26 vdout1_26ck109 = 1.6 time = 1100
* CHECK dout1_27 vdout1_27ck109 = 0 time = 1100
* CHECK dout1_28 vdout1_28ck109 = 0 time = 1100
* CHECK dout1_29 vdout1_29ck109 = 0 time = 1100
* CHECK dout1_30 vdout1_30ck109 = 1.6 time = 1100
* CHECK dout1_31 vdout1_31ck109 = 1.6 time = 1100
* CHECK dout1_32 vdout1_32ck109 = 0 time = 1100
* CHECK dout0_0 vdout0_0ck110 = 1.6 time = 1110
* CHECK dout0_1 vdout0_1ck110 = 0 time = 1110
* CHECK dout0_2 vdout0_2ck110 = 0 time = 1110
* CHECK dout0_3 vdout0_3ck110 = 1.6 time = 1110
* CHECK dout0_4 vdout0_4ck110 = 0 time = 1110
* CHECK dout0_5 vdout0_5ck110 = 1.6 time = 1110
* CHECK dout0_6 vdout0_6ck110 = 0 time = 1110
* CHECK dout0_7 vdout0_7ck110 = 1.6 time = 1110
* CHECK dout0_8 vdout0_8ck110 = 0 time = 1110
* CHECK dout0_9 vdout0_9ck110 = 0 time = 1110
* CHECK dout0_10 vdout0_10ck110 = 0 time = 1110
* CHECK dout0_11 vdout0_11ck110 = 1.6 time = 1110
* CHECK dout0_12 vdout0_12ck110 = 0 time = 1110
* CHECK dout0_13 vdout0_13ck110 = 1.6 time = 1110
* CHECK dout0_14 vdout0_14ck110 = 0 time = 1110
* CHECK dout0_15 vdout0_15ck110 = 1.6 time = 1110
* CHECK dout0_16 vdout0_16ck110 = 1.6 time = 1110
* CHECK dout0_17 vdout0_17ck110 = 1.6 time = 1110
* CHECK dout0_18 vdout0_18ck110 = 0 time = 1110
* CHECK dout0_19 vdout0_19ck110 = 0 time = 1110
* CHECK dout0_20 vdout0_20ck110 = 1.6 time = 1110
* CHECK dout0_21 vdout0_21ck110 = 1.6 time = 1110
* CHECK dout0_22 vdout0_22ck110 = 0 time = 1110
* CHECK dout0_23 vdout0_23ck110 = 0 time = 1110
* CHECK dout0_24 vdout0_24ck110 = 1.6 time = 1110
* CHECK dout0_25 vdout0_25ck110 = 1.6 time = 1110
* CHECK dout0_26 vdout0_26ck110 = 1.6 time = 1110
* CHECK dout0_27 vdout0_27ck110 = 1.6 time = 1110
* CHECK dout0_28 vdout0_28ck110 = 0 time = 1110
* CHECK dout0_29 vdout0_29ck110 = 1.6 time = 1110
* CHECK dout0_30 vdout0_30ck110 = 0 time = 1110
* CHECK dout0_31 vdout0_31ck110 = 0 time = 1110
* CHECK dout0_32 vdout0_32ck110 = 0 time = 1110
* CHECK dout1_0 vdout1_0ck110 = 1.6 time = 1110
* CHECK dout1_1 vdout1_1ck110 = 0 time = 1110
* CHECK dout1_2 vdout1_2ck110 = 0 time = 1110
* CHECK dout1_3 vdout1_3ck110 = 1.6 time = 1110
* CHECK dout1_4 vdout1_4ck110 = 0 time = 1110
* CHECK dout1_5 vdout1_5ck110 = 1.6 time = 1110
* CHECK dout1_6 vdout1_6ck110 = 0 time = 1110
* CHECK dout1_7 vdout1_7ck110 = 1.6 time = 1110
* CHECK dout1_8 vdout1_8ck110 = 0 time = 1110
* CHECK dout1_9 vdout1_9ck110 = 0 time = 1110
* CHECK dout1_10 vdout1_10ck110 = 0 time = 1110
* CHECK dout1_11 vdout1_11ck110 = 1.6 time = 1110
* CHECK dout1_12 vdout1_12ck110 = 0 time = 1110
* CHECK dout1_13 vdout1_13ck110 = 1.6 time = 1110
* CHECK dout1_14 vdout1_14ck110 = 0 time = 1110
* CHECK dout1_15 vdout1_15ck110 = 1.6 time = 1110
* CHECK dout1_16 vdout1_16ck110 = 1.6 time = 1110
* CHECK dout1_17 vdout1_17ck110 = 1.6 time = 1110
* CHECK dout1_18 vdout1_18ck110 = 0 time = 1110
* CHECK dout1_19 vdout1_19ck110 = 0 time = 1110
* CHECK dout1_20 vdout1_20ck110 = 1.6 time = 1110
* CHECK dout1_21 vdout1_21ck110 = 1.6 time = 1110
* CHECK dout1_22 vdout1_22ck110 = 0 time = 1110
* CHECK dout1_23 vdout1_23ck110 = 0 time = 1110
* CHECK dout1_24 vdout1_24ck110 = 1.6 time = 1110
* CHECK dout1_25 vdout1_25ck110 = 1.6 time = 1110
* CHECK dout1_26 vdout1_26ck110 = 1.6 time = 1110
* CHECK dout1_27 vdout1_27ck110 = 1.6 time = 1110
* CHECK dout1_28 vdout1_28ck110 = 0 time = 1110
* CHECK dout1_29 vdout1_29ck110 = 1.6 time = 1110
* CHECK dout1_30 vdout1_30ck110 = 0 time = 1110
* CHECK dout1_31 vdout1_31ck110 = 0 time = 1110
* CHECK dout1_32 vdout1_32ck110 = 0 time = 1110
* CHECK dout0_0 vdout0_0ck111 = 1.6 time = 1120
* CHECK dout0_1 vdout0_1ck111 = 0 time = 1120
* CHECK dout0_2 vdout0_2ck111 = 0 time = 1120
* CHECK dout0_3 vdout0_3ck111 = 1.6 time = 1120
* CHECK dout0_4 vdout0_4ck111 = 0 time = 1120
* CHECK dout0_5 vdout0_5ck111 = 1.6 time = 1120
* CHECK dout0_6 vdout0_6ck111 = 0 time = 1120
* CHECK dout0_7 vdout0_7ck111 = 1.6 time = 1120
* CHECK dout0_8 vdout0_8ck111 = 0 time = 1120
* CHECK dout0_9 vdout0_9ck111 = 0 time = 1120
* CHECK dout0_10 vdout0_10ck111 = 0 time = 1120
* CHECK dout0_11 vdout0_11ck111 = 1.6 time = 1120
* CHECK dout0_12 vdout0_12ck111 = 0 time = 1120
* CHECK dout0_13 vdout0_13ck111 = 1.6 time = 1120
* CHECK dout0_14 vdout0_14ck111 = 0 time = 1120
* CHECK dout0_15 vdout0_15ck111 = 1.6 time = 1120
* CHECK dout0_16 vdout0_16ck111 = 1.6 time = 1120
* CHECK dout0_17 vdout0_17ck111 = 1.6 time = 1120
* CHECK dout0_18 vdout0_18ck111 = 0 time = 1120
* CHECK dout0_19 vdout0_19ck111 = 0 time = 1120
* CHECK dout0_20 vdout0_20ck111 = 1.6 time = 1120
* CHECK dout0_21 vdout0_21ck111 = 1.6 time = 1120
* CHECK dout0_22 vdout0_22ck111 = 0 time = 1120
* CHECK dout0_23 vdout0_23ck111 = 0 time = 1120
* CHECK dout0_24 vdout0_24ck111 = 1.6 time = 1120
* CHECK dout0_25 vdout0_25ck111 = 1.6 time = 1120
* CHECK dout0_26 vdout0_26ck111 = 1.6 time = 1120
* CHECK dout0_27 vdout0_27ck111 = 1.6 time = 1120
* CHECK dout0_28 vdout0_28ck111 = 0 time = 1120
* CHECK dout0_29 vdout0_29ck111 = 1.6 time = 1120
* CHECK dout0_30 vdout0_30ck111 = 0 time = 1120
* CHECK dout0_31 vdout0_31ck111 = 0 time = 1120
* CHECK dout0_32 vdout0_32ck111 = 0 time = 1120
* CHECK dout0_0 vdout0_0ck112 = 1.6 time = 1130
* CHECK dout0_1 vdout0_1ck112 = 1.6 time = 1130
* CHECK dout0_2 vdout0_2ck112 = 1.6 time = 1130
* CHECK dout0_3 vdout0_3ck112 = 1.6 time = 1130
* CHECK dout0_4 vdout0_4ck112 = 1.6 time = 1130
* CHECK dout0_5 vdout0_5ck112 = 0 time = 1130
* CHECK dout0_6 vdout0_6ck112 = 0 time = 1130
* CHECK dout0_7 vdout0_7ck112 = 1.6 time = 1130
* CHECK dout0_8 vdout0_8ck112 = 1.6 time = 1130
* CHECK dout0_9 vdout0_9ck112 = 0 time = 1130
* CHECK dout0_10 vdout0_10ck112 = 0 time = 1130
* CHECK dout0_11 vdout0_11ck112 = 1.6 time = 1130
* CHECK dout0_12 vdout0_12ck112 = 0 time = 1130
* CHECK dout0_13 vdout0_13ck112 = 0 time = 1130
* CHECK dout0_14 vdout0_14ck112 = 0 time = 1130
* CHECK dout0_15 vdout0_15ck112 = 0 time = 1130
* CHECK dout0_16 vdout0_16ck112 = 1.6 time = 1130
* CHECK dout0_17 vdout0_17ck112 = 1.6 time = 1130
* CHECK dout0_18 vdout0_18ck112 = 1.6 time = 1130
* CHECK dout0_19 vdout0_19ck112 = 0 time = 1130
* CHECK dout0_20 vdout0_20ck112 = 0 time = 1130
* CHECK dout0_21 vdout0_21ck112 = 0 time = 1130
* CHECK dout0_22 vdout0_22ck112 = 1.6 time = 1130
* CHECK dout0_23 vdout0_23ck112 = 0 time = 1130
* CHECK dout0_24 vdout0_24ck112 = 1.6 time = 1130
* CHECK dout0_25 vdout0_25ck112 = 1.6 time = 1130
* CHECK dout0_26 vdout0_26ck112 = 1.6 time = 1130
* CHECK dout0_27 vdout0_27ck112 = 0 time = 1130
* CHECK dout0_28 vdout0_28ck112 = 1.6 time = 1130
* CHECK dout0_29 vdout0_29ck112 = 0 time = 1130
* CHECK dout0_30 vdout0_30ck112 = 1.6 time = 1130
* CHECK dout0_31 vdout0_31ck112 = 1.6 time = 1130
* CHECK dout0_32 vdout0_32ck112 = 0 time = 1130
* CHECK dout1_0 vdout1_0ck112 = 1.6 time = 1130
* CHECK dout1_1 vdout1_1ck112 = 1.6 time = 1130
* CHECK dout1_2 vdout1_2ck112 = 1.6 time = 1130
* CHECK dout1_3 vdout1_3ck112 = 0 time = 1130
* CHECK dout1_4 vdout1_4ck112 = 0 time = 1130
* CHECK dout1_5 vdout1_5ck112 = 1.6 time = 1130
* CHECK dout1_6 vdout1_6ck112 = 1.6 time = 1130
* CHECK dout1_7 vdout1_7ck112 = 1.6 time = 1130
* CHECK dout1_8 vdout1_8ck112 = 1.6 time = 1130
* CHECK dout1_9 vdout1_9ck112 = 1.6 time = 1130
* CHECK dout1_10 vdout1_10ck112 = 1.6 time = 1130
* CHECK dout1_11 vdout1_11ck112 = 1.6 time = 1130
* CHECK dout1_12 vdout1_12ck112 = 1.6 time = 1130
* CHECK dout1_13 vdout1_13ck112 = 1.6 time = 1130
* CHECK dout1_14 vdout1_14ck112 = 1.6 time = 1130
* CHECK dout1_15 vdout1_15ck112 = 0 time = 1130
* CHECK dout1_16 vdout1_16ck112 = 0 time = 1130
* CHECK dout1_17 vdout1_17ck112 = 1.6 time = 1130
* CHECK dout1_18 vdout1_18ck112 = 1.6 time = 1130
* CHECK dout1_19 vdout1_19ck112 = 0 time = 1130
* CHECK dout1_20 vdout1_20ck112 = 1.6 time = 1130
* CHECK dout1_21 vdout1_21ck112 = 1.6 time = 1130
* CHECK dout1_22 vdout1_22ck112 = 0 time = 1130
* CHECK dout1_23 vdout1_23ck112 = 0 time = 1130
* CHECK dout1_24 vdout1_24ck112 = 1.6 time = 1130
* CHECK dout1_25 vdout1_25ck112 = 1.6 time = 1130
* CHECK dout1_26 vdout1_26ck112 = 0 time = 1130
* CHECK dout1_27 vdout1_27ck112 = 0 time = 1130
* CHECK dout1_28 vdout1_28ck112 = 0 time = 1130
* CHECK dout1_29 vdout1_29ck112 = 1.6 time = 1130
* CHECK dout1_30 vdout1_30ck112 = 0 time = 1130
* CHECK dout1_31 vdout1_31ck112 = 0 time = 1130
* CHECK dout1_32 vdout1_32ck112 = 0 time = 1130
* CHECK dout1_0 vdout1_0ck113 = 1.6 time = 1140
* CHECK dout1_1 vdout1_1ck113 = 1.6 time = 1140
* CHECK dout1_2 vdout1_2ck113 = 1.6 time = 1140
* CHECK dout1_3 vdout1_3ck113 = 1.6 time = 1140
* CHECK dout1_4 vdout1_4ck113 = 1.6 time = 1140
* CHECK dout1_5 vdout1_5ck113 = 0 time = 1140
* CHECK dout1_6 vdout1_6ck113 = 0 time = 1140
* CHECK dout1_7 vdout1_7ck113 = 1.6 time = 1140
* CHECK dout1_8 vdout1_8ck113 = 1.6 time = 1140
* CHECK dout1_9 vdout1_9ck113 = 0 time = 1140
* CHECK dout1_10 vdout1_10ck113 = 0 time = 1140
* CHECK dout1_11 vdout1_11ck113 = 1.6 time = 1140
* CHECK dout1_12 vdout1_12ck113 = 0 time = 1140
* CHECK dout1_13 vdout1_13ck113 = 0 time = 1140
* CHECK dout1_14 vdout1_14ck113 = 0 time = 1140
* CHECK dout1_15 vdout1_15ck113 = 0 time = 1140
* CHECK dout1_16 vdout1_16ck113 = 1.6 time = 1140
* CHECK dout1_17 vdout1_17ck113 = 1.6 time = 1140
* CHECK dout1_18 vdout1_18ck113 = 1.6 time = 1140
* CHECK dout1_19 vdout1_19ck113 = 0 time = 1140
* CHECK dout1_20 vdout1_20ck113 = 0 time = 1140
* CHECK dout1_21 vdout1_21ck113 = 0 time = 1140
* CHECK dout1_22 vdout1_22ck113 = 1.6 time = 1140
* CHECK dout1_23 vdout1_23ck113 = 0 time = 1140
* CHECK dout1_24 vdout1_24ck113 = 1.6 time = 1140
* CHECK dout1_25 vdout1_25ck113 = 1.6 time = 1140
* CHECK dout1_26 vdout1_26ck113 = 1.6 time = 1140
* CHECK dout1_27 vdout1_27ck113 = 0 time = 1140
* CHECK dout1_28 vdout1_28ck113 = 1.6 time = 1140
* CHECK dout1_29 vdout1_29ck113 = 0 time = 1140
* CHECK dout1_30 vdout1_30ck113 = 1.6 time = 1140
* CHECK dout1_31 vdout1_31ck113 = 1.6 time = 1140
* CHECK dout1_32 vdout1_32ck113 = 0 time = 1140
* CHECK dout0_0 vdout0_0ck114 = 0 time = 1150
* CHECK dout0_1 vdout0_1ck114 = 1.6 time = 1150
* CHECK dout0_2 vdout0_2ck114 = 1.6 time = 1150
* CHECK dout0_3 vdout0_3ck114 = 1.6 time = 1150
* CHECK dout0_4 vdout0_4ck114 = 0 time = 1150
* CHECK dout0_5 vdout0_5ck114 = 0 time = 1150
* CHECK dout0_6 vdout0_6ck114 = 1.6 time = 1150
* CHECK dout0_7 vdout0_7ck114 = 1.6 time = 1150
* CHECK dout0_8 vdout0_8ck114 = 1.6 time = 1150
* CHECK dout0_9 vdout0_9ck114 = 0 time = 1150
* CHECK dout0_10 vdout0_10ck114 = 0 time = 1150
* CHECK dout0_11 vdout0_11ck114 = 0 time = 1150
* CHECK dout0_12 vdout0_12ck114 = 1.6 time = 1150
* CHECK dout0_13 vdout0_13ck114 = 1.6 time = 1150
* CHECK dout0_14 vdout0_14ck114 = 0 time = 1150
* CHECK dout0_15 vdout0_15ck114 = 0 time = 1150
* CHECK dout0_16 vdout0_16ck114 = 1.6 time = 1150
* CHECK dout0_17 vdout0_17ck114 = 0 time = 1150
* CHECK dout0_18 vdout0_18ck114 = 1.6 time = 1150
* CHECK dout0_19 vdout0_19ck114 = 1.6 time = 1150
* CHECK dout0_20 vdout0_20ck114 = 1.6 time = 1150
* CHECK dout0_21 vdout0_21ck114 = 0 time = 1150
* CHECK dout0_22 vdout0_22ck114 = 0 time = 1150
* CHECK dout0_23 vdout0_23ck114 = 1.6 time = 1150
* CHECK dout0_24 vdout0_24ck114 = 0 time = 1150
* CHECK dout0_25 vdout0_25ck114 = 1.6 time = 1150
* CHECK dout0_26 vdout0_26ck114 = 1.6 time = 1150
* CHECK dout0_27 vdout0_27ck114 = 0 time = 1150
* CHECK dout0_28 vdout0_28ck114 = 0 time = 1150
* CHECK dout0_29 vdout0_29ck114 = 0 time = 1150
* CHECK dout0_30 vdout0_30ck114 = 1.6 time = 1150
* CHECK dout0_31 vdout0_31ck114 = 1.6 time = 1150
* CHECK dout0_32 vdout0_32ck114 = 0 time = 1150
* CHECK dout1_0 vdout1_0ck114 = 1.6 time = 1150
* CHECK dout1_1 vdout1_1ck114 = 1.6 time = 1150
* CHECK dout1_2 vdout1_2ck114 = 1.6 time = 1150
* CHECK dout1_3 vdout1_3ck114 = 0 time = 1150
* CHECK dout1_4 vdout1_4ck114 = 0 time = 1150
* CHECK dout1_5 vdout1_5ck114 = 1.6 time = 1150
* CHECK dout1_6 vdout1_6ck114 = 1.6 time = 1150
* CHECK dout1_7 vdout1_7ck114 = 1.6 time = 1150
* CHECK dout1_8 vdout1_8ck114 = 1.6 time = 1150
* CHECK dout1_9 vdout1_9ck114 = 1.6 time = 1150
* CHECK dout1_10 vdout1_10ck114 = 1.6 time = 1150
* CHECK dout1_11 vdout1_11ck114 = 1.6 time = 1150
* CHECK dout1_12 vdout1_12ck114 = 1.6 time = 1150
* CHECK dout1_13 vdout1_13ck114 = 1.6 time = 1150
* CHECK dout1_14 vdout1_14ck114 = 1.6 time = 1150
* CHECK dout1_15 vdout1_15ck114 = 0 time = 1150
* CHECK dout1_16 vdout1_16ck114 = 0 time = 1150
* CHECK dout1_17 vdout1_17ck114 = 1.6 time = 1150
* CHECK dout1_18 vdout1_18ck114 = 1.6 time = 1150
* CHECK dout1_19 vdout1_19ck114 = 0 time = 1150
* CHECK dout1_20 vdout1_20ck114 = 1.6 time = 1150
* CHECK dout1_21 vdout1_21ck114 = 1.6 time = 1150
* CHECK dout1_22 vdout1_22ck114 = 0 time = 1150
* CHECK dout1_23 vdout1_23ck114 = 0 time = 1150
* CHECK dout1_24 vdout1_24ck114 = 1.6 time = 1150
* CHECK dout1_25 vdout1_25ck114 = 1.6 time = 1150
* CHECK dout1_26 vdout1_26ck114 = 0 time = 1150
* CHECK dout1_27 vdout1_27ck114 = 0 time = 1150
* CHECK dout1_28 vdout1_28ck114 = 0 time = 1150
* CHECK dout1_29 vdout1_29ck114 = 1.6 time = 1150
* CHECK dout1_30 vdout1_30ck114 = 0 time = 1150
* CHECK dout1_31 vdout1_31ck114 = 0 time = 1150
* CHECK dout1_32 vdout1_32ck114 = 0 time = 1150
* CHECK dout0_0 vdout0_0ck117 = 1.6 time = 1180
* CHECK dout0_1 vdout0_1ck117 = 1.6 time = 1180
* CHECK dout0_2 vdout0_2ck117 = 0 time = 1180
* CHECK dout0_3 vdout0_3ck117 = 0 time = 1180
* CHECK dout0_4 vdout0_4ck117 = 0 time = 1180
* CHECK dout0_5 vdout0_5ck117 = 0 time = 1180
* CHECK dout0_6 vdout0_6ck117 = 1.6 time = 1180
* CHECK dout0_7 vdout0_7ck117 = 0 time = 1180
* CHECK dout0_8 vdout0_8ck117 = 1.6 time = 1180
* CHECK dout0_9 vdout0_9ck117 = 1.6 time = 1180
* CHECK dout0_10 vdout0_10ck117 = 0 time = 1180
* CHECK dout0_11 vdout0_11ck117 = 1.6 time = 1180
* CHECK dout0_12 vdout0_12ck117 = 1.6 time = 1180
* CHECK dout0_13 vdout0_13ck117 = 1.6 time = 1180
* CHECK dout0_14 vdout0_14ck117 = 0 time = 1180
* CHECK dout0_15 vdout0_15ck117 = 0 time = 1180
* CHECK dout0_16 vdout0_16ck117 = 0 time = 1180
* CHECK dout0_17 vdout0_17ck117 = 0 time = 1180
* CHECK dout0_18 vdout0_18ck117 = 1.6 time = 1180
* CHECK dout0_19 vdout0_19ck117 = 1.6 time = 1180
* CHECK dout0_20 vdout0_20ck117 = 0 time = 1180
* CHECK dout0_21 vdout0_21ck117 = 0 time = 1180
* CHECK dout0_22 vdout0_22ck117 = 0 time = 1180
* CHECK dout0_23 vdout0_23ck117 = 1.6 time = 1180
* CHECK dout0_24 vdout0_24ck117 = 1.6 time = 1180
* CHECK dout0_25 vdout0_25ck117 = 1.6 time = 1180
* CHECK dout0_26 vdout0_26ck117 = 1.6 time = 1180
* CHECK dout0_27 vdout0_27ck117 = 0 time = 1180
* CHECK dout0_28 vdout0_28ck117 = 0 time = 1180
* CHECK dout0_29 vdout0_29ck117 = 0 time = 1180
* CHECK dout0_30 vdout0_30ck117 = 0 time = 1180
* CHECK dout0_31 vdout0_31ck117 = 0 time = 1180
* CHECK dout0_32 vdout0_32ck117 = 0 time = 1180
* CHECK dout1_0 vdout1_0ck117 = 0 time = 1180
* CHECK dout1_1 vdout1_1ck117 = 1.6 time = 1180
* CHECK dout1_2 vdout1_2ck117 = 0 time = 1180
* CHECK dout1_3 vdout1_3ck117 = 0 time = 1180
* CHECK dout1_4 vdout1_4ck117 = 0 time = 1180
* CHECK dout1_5 vdout1_5ck117 = 0 time = 1180
* CHECK dout1_6 vdout1_6ck117 = 1.6 time = 1180
* CHECK dout1_7 vdout1_7ck117 = 0 time = 1180
* CHECK dout1_8 vdout1_8ck117 = 0 time = 1180
* CHECK dout1_9 vdout1_9ck117 = 1.6 time = 1180
* CHECK dout1_10 vdout1_10ck117 = 0 time = 1180
* CHECK dout1_11 vdout1_11ck117 = 1.6 time = 1180
* CHECK dout1_12 vdout1_12ck117 = 0 time = 1180
* CHECK dout1_13 vdout1_13ck117 = 1.6 time = 1180
* CHECK dout1_14 vdout1_14ck117 = 0 time = 1180
* CHECK dout1_15 vdout1_15ck117 = 1.6 time = 1180
* CHECK dout1_16 vdout1_16ck117 = 0 time = 1180
* CHECK dout1_17 vdout1_17ck117 = 1.6 time = 1180
* CHECK dout1_18 vdout1_18ck117 = 0 time = 1180
* CHECK dout1_19 vdout1_19ck117 = 0 time = 1180
* CHECK dout1_20 vdout1_20ck117 = 1.6 time = 1180
* CHECK dout1_21 vdout1_21ck117 = 1.6 time = 1180
* CHECK dout1_22 vdout1_22ck117 = 0 time = 1180
* CHECK dout1_23 vdout1_23ck117 = 0 time = 1180
* CHECK dout1_24 vdout1_24ck117 = 0 time = 1180
* CHECK dout1_25 vdout1_25ck117 = 1.6 time = 1180
* CHECK dout1_26 vdout1_26ck117 = 1.6 time = 1180
* CHECK dout1_27 vdout1_27ck117 = 1.6 time = 1180
* CHECK dout1_28 vdout1_28ck117 = 1.6 time = 1180
* CHECK dout1_29 vdout1_29ck117 = 0 time = 1180
* CHECK dout1_30 vdout1_30ck117 = 1.6 time = 1180
* CHECK dout1_31 vdout1_31ck117 = 1.6 time = 1180
* CHECK dout1_32 vdout1_32ck117 = 0 time = 1180
* CHECK dout1_0 vdout1_0ck118 = 0 time = 1190
* CHECK dout1_1 vdout1_1ck118 = 1.6 time = 1190
* CHECK dout1_2 vdout1_2ck118 = 0 time = 1190
* CHECK dout1_3 vdout1_3ck118 = 0 time = 1190
* CHECK dout1_4 vdout1_4ck118 = 0 time = 1190
* CHECK dout1_5 vdout1_5ck118 = 0 time = 1190
* CHECK dout1_6 vdout1_6ck118 = 1.6 time = 1190
* CHECK dout1_7 vdout1_7ck118 = 0 time = 1190
* CHECK dout1_8 vdout1_8ck118 = 0 time = 1190
* CHECK dout1_9 vdout1_9ck118 = 1.6 time = 1190
* CHECK dout1_10 vdout1_10ck118 = 0 time = 1190
* CHECK dout1_11 vdout1_11ck118 = 1.6 time = 1190
* CHECK dout1_12 vdout1_12ck118 = 0 time = 1190
* CHECK dout1_13 vdout1_13ck118 = 1.6 time = 1190
* CHECK dout1_14 vdout1_14ck118 = 0 time = 1190
* CHECK dout1_15 vdout1_15ck118 = 1.6 time = 1190
* CHECK dout1_16 vdout1_16ck118 = 0 time = 1190
* CHECK dout1_17 vdout1_17ck118 = 1.6 time = 1190
* CHECK dout1_18 vdout1_18ck118 = 0 time = 1190
* CHECK dout1_19 vdout1_19ck118 = 0 time = 1190
* CHECK dout1_20 vdout1_20ck118 = 1.6 time = 1190
* CHECK dout1_21 vdout1_21ck118 = 1.6 time = 1190
* CHECK dout1_22 vdout1_22ck118 = 0 time = 1190
* CHECK dout1_23 vdout1_23ck118 = 0 time = 1190
* CHECK dout1_24 vdout1_24ck118 = 0 time = 1190
* CHECK dout1_25 vdout1_25ck118 = 1.6 time = 1190
* CHECK dout1_26 vdout1_26ck118 = 1.6 time = 1190
* CHECK dout1_27 vdout1_27ck118 = 1.6 time = 1190
* CHECK dout1_28 vdout1_28ck118 = 1.6 time = 1190
* CHECK dout1_29 vdout1_29ck118 = 0 time = 1190
* CHECK dout1_30 vdout1_30ck118 = 1.6 time = 1190
* CHECK dout1_31 vdout1_31ck118 = 1.6 time = 1190
* CHECK dout1_32 vdout1_32ck118 = 0 time = 1190
* CHECK dout1_0 vdout1_0ck119 = 1.6 time = 1200
* CHECK dout1_1 vdout1_1ck119 = 1.6 time = 1200
* CHECK dout1_2 vdout1_2ck119 = 1.6 time = 1200
* CHECK dout1_3 vdout1_3ck119 = 0 time = 1200
* CHECK dout1_4 vdout1_4ck119 = 0 time = 1200
* CHECK dout1_5 vdout1_5ck119 = 1.6 time = 1200
* CHECK dout1_6 vdout1_6ck119 = 1.6 time = 1200
* CHECK dout1_7 vdout1_7ck119 = 1.6 time = 1200
* CHECK dout1_8 vdout1_8ck119 = 1.6 time = 1200
* CHECK dout1_9 vdout1_9ck119 = 1.6 time = 1200
* CHECK dout1_10 vdout1_10ck119 = 1.6 time = 1200
* CHECK dout1_11 vdout1_11ck119 = 1.6 time = 1200
* CHECK dout1_12 vdout1_12ck119 = 1.6 time = 1200
* CHECK dout1_13 vdout1_13ck119 = 1.6 time = 1200
* CHECK dout1_14 vdout1_14ck119 = 1.6 time = 1200
* CHECK dout1_15 vdout1_15ck119 = 0 time = 1200
* CHECK dout1_16 vdout1_16ck119 = 0 time = 1200
* CHECK dout1_17 vdout1_17ck119 = 1.6 time = 1200
* CHECK dout1_18 vdout1_18ck119 = 1.6 time = 1200
* CHECK dout1_19 vdout1_19ck119 = 0 time = 1200
* CHECK dout1_20 vdout1_20ck119 = 1.6 time = 1200
* CHECK dout1_21 vdout1_21ck119 = 1.6 time = 1200
* CHECK dout1_22 vdout1_22ck119 = 0 time = 1200
* CHECK dout1_23 vdout1_23ck119 = 0 time = 1200
* CHECK dout1_24 vdout1_24ck119 = 1.6 time = 1200
* CHECK dout1_25 vdout1_25ck119 = 1.6 time = 1200
* CHECK dout1_26 vdout1_26ck119 = 0 time = 1200
* CHECK dout1_27 vdout1_27ck119 = 0 time = 1200
* CHECK dout1_28 vdout1_28ck119 = 0 time = 1200
* CHECK dout1_29 vdout1_29ck119 = 1.6 time = 1200
* CHECK dout1_30 vdout1_30ck119 = 0 time = 1200
* CHECK dout1_31 vdout1_31ck119 = 0 time = 1200
* CHECK dout1_32 vdout1_32ck119 = 0 time = 1200
* CHECK dout0_0 vdout0_0ck120 = 1.6 time = 1210
* CHECK dout0_1 vdout0_1ck120 = 1.6 time = 1210
* CHECK dout0_2 vdout0_2ck120 = 0 time = 1210
* CHECK dout0_3 vdout0_3ck120 = 0 time = 1210
* CHECK dout0_4 vdout0_4ck120 = 0 time = 1210
* CHECK dout0_5 vdout0_5ck120 = 0 time = 1210
* CHECK dout0_6 vdout0_6ck120 = 1.6 time = 1210
* CHECK dout0_7 vdout0_7ck120 = 0 time = 1210
* CHECK dout0_8 vdout0_8ck120 = 1.6 time = 1210
* CHECK dout0_9 vdout0_9ck120 = 1.6 time = 1210
* CHECK dout0_10 vdout0_10ck120 = 0 time = 1210
* CHECK dout0_11 vdout0_11ck120 = 1.6 time = 1210
* CHECK dout0_12 vdout0_12ck120 = 1.6 time = 1210
* CHECK dout0_13 vdout0_13ck120 = 1.6 time = 1210
* CHECK dout0_14 vdout0_14ck120 = 0 time = 1210
* CHECK dout0_15 vdout0_15ck120 = 0 time = 1210
* CHECK dout0_16 vdout0_16ck120 = 0 time = 1210
* CHECK dout0_17 vdout0_17ck120 = 0 time = 1210
* CHECK dout0_18 vdout0_18ck120 = 1.6 time = 1210
* CHECK dout0_19 vdout0_19ck120 = 1.6 time = 1210
* CHECK dout0_20 vdout0_20ck120 = 0 time = 1210
* CHECK dout0_21 vdout0_21ck120 = 0 time = 1210
* CHECK dout0_22 vdout0_22ck120 = 0 time = 1210
* CHECK dout0_23 vdout0_23ck120 = 1.6 time = 1210
* CHECK dout0_24 vdout0_24ck120 = 1.6 time = 1210
* CHECK dout0_25 vdout0_25ck120 = 1.6 time = 1210
* CHECK dout0_26 vdout0_26ck120 = 1.6 time = 1210
* CHECK dout0_27 vdout0_27ck120 = 0 time = 1210
* CHECK dout0_28 vdout0_28ck120 = 0 time = 1210
* CHECK dout0_29 vdout0_29ck120 = 0 time = 1210
* CHECK dout0_30 vdout0_30ck120 = 0 time = 1210
* CHECK dout0_31 vdout0_31ck120 = 0 time = 1210
* CHECK dout0_32 vdout0_32ck120 = 0 time = 1210
* CHECK dout1_0 vdout1_0ck120 = 1.6 time = 1210
* CHECK dout1_1 vdout1_1ck120 = 1.6 time = 1210
* CHECK dout1_2 vdout1_2ck120 = 1.6 time = 1210
* CHECK dout1_3 vdout1_3ck120 = 1.6 time = 1210
* CHECK dout1_4 vdout1_4ck120 = 1.6 time = 1210
* CHECK dout1_5 vdout1_5ck120 = 0 time = 1210
* CHECK dout1_6 vdout1_6ck120 = 0 time = 1210
* CHECK dout1_7 vdout1_7ck120 = 1.6 time = 1210
* CHECK dout1_8 vdout1_8ck120 = 1.6 time = 1210
* CHECK dout1_9 vdout1_9ck120 = 0 time = 1210
* CHECK dout1_10 vdout1_10ck120 = 0 time = 1210
* CHECK dout1_11 vdout1_11ck120 = 1.6 time = 1210
* CHECK dout1_12 vdout1_12ck120 = 0 time = 1210
* CHECK dout1_13 vdout1_13ck120 = 0 time = 1210
* CHECK dout1_14 vdout1_14ck120 = 0 time = 1210
* CHECK dout1_15 vdout1_15ck120 = 0 time = 1210
* CHECK dout1_16 vdout1_16ck120 = 1.6 time = 1210
* CHECK dout1_17 vdout1_17ck120 = 1.6 time = 1210
* CHECK dout1_18 vdout1_18ck120 = 1.6 time = 1210
* CHECK dout1_19 vdout1_19ck120 = 0 time = 1210
* CHECK dout1_20 vdout1_20ck120 = 0 time = 1210
* CHECK dout1_21 vdout1_21ck120 = 0 time = 1210
* CHECK dout1_22 vdout1_22ck120 = 1.6 time = 1210
* CHECK dout1_23 vdout1_23ck120 = 0 time = 1210
* CHECK dout1_24 vdout1_24ck120 = 1.6 time = 1210
* CHECK dout1_25 vdout1_25ck120 = 1.6 time = 1210
* CHECK dout1_26 vdout1_26ck120 = 1.6 time = 1210
* CHECK dout1_27 vdout1_27ck120 = 0 time = 1210
* CHECK dout1_28 vdout1_28ck120 = 1.6 time = 1210
* CHECK dout1_29 vdout1_29ck120 = 0 time = 1210
* CHECK dout1_30 vdout1_30ck120 = 1.6 time = 1210
* CHECK dout1_31 vdout1_31ck120 = 1.6 time = 1210
* CHECK dout1_32 vdout1_32ck120 = 0 time = 1210
* CHECK dout1_0 vdout1_0ck121 = 1.6 time = 1220
* CHECK dout1_1 vdout1_1ck121 = 1.6 time = 1220
* CHECK dout1_2 vdout1_2ck121 = 1.6 time = 1220
* CHECK dout1_3 vdout1_3ck121 = 1.6 time = 1220
* CHECK dout1_4 vdout1_4ck121 = 1.6 time = 1220
* CHECK dout1_5 vdout1_5ck121 = 0 time = 1220
* CHECK dout1_6 vdout1_6ck121 = 0 time = 1220
* CHECK dout1_7 vdout1_7ck121 = 1.6 time = 1220
* CHECK dout1_8 vdout1_8ck121 = 1.6 time = 1220
* CHECK dout1_9 vdout1_9ck121 = 0 time = 1220
* CHECK dout1_10 vdout1_10ck121 = 0 time = 1220
* CHECK dout1_11 vdout1_11ck121 = 1.6 time = 1220
* CHECK dout1_12 vdout1_12ck121 = 0 time = 1220
* CHECK dout1_13 vdout1_13ck121 = 0 time = 1220
* CHECK dout1_14 vdout1_14ck121 = 0 time = 1220
* CHECK dout1_15 vdout1_15ck121 = 0 time = 1220
* CHECK dout1_16 vdout1_16ck121 = 1.6 time = 1220
* CHECK dout1_17 vdout1_17ck121 = 1.6 time = 1220
* CHECK dout1_18 vdout1_18ck121 = 1.6 time = 1220
* CHECK dout1_19 vdout1_19ck121 = 0 time = 1220
* CHECK dout1_20 vdout1_20ck121 = 0 time = 1220
* CHECK dout1_21 vdout1_21ck121 = 0 time = 1220
* CHECK dout1_22 vdout1_22ck121 = 1.6 time = 1220
* CHECK dout1_23 vdout1_23ck121 = 0 time = 1220
* CHECK dout1_24 vdout1_24ck121 = 1.6 time = 1220
* CHECK dout1_25 vdout1_25ck121 = 1.6 time = 1220
* CHECK dout1_26 vdout1_26ck121 = 1.6 time = 1220
* CHECK dout1_27 vdout1_27ck121 = 0 time = 1220
* CHECK dout1_28 vdout1_28ck121 = 1.6 time = 1220
* CHECK dout1_29 vdout1_29ck121 = 0 time = 1220
* CHECK dout1_30 vdout1_30ck121 = 1.6 time = 1220
* CHECK dout1_31 vdout1_31ck121 = 1.6 time = 1220
* CHECK dout1_32 vdout1_32ck121 = 0 time = 1220
* CHECK dout0_0 vdout0_0ck122 = 1.6 time = 1230
* CHECK dout0_1 vdout0_1ck122 = 1.6 time = 1230
* CHECK dout0_2 vdout0_2ck122 = 1.6 time = 1230
* CHECK dout0_3 vdout0_3ck122 = 0 time = 1230
* CHECK dout0_4 vdout0_4ck122 = 0 time = 1230
* CHECK dout0_5 vdout0_5ck122 = 1.6 time = 1230
* CHECK dout0_6 vdout0_6ck122 = 1.6 time = 1230
* CHECK dout0_7 vdout0_7ck122 = 1.6 time = 1230
* CHECK dout0_8 vdout0_8ck122 = 1.6 time = 1230
* CHECK dout0_9 vdout0_9ck122 = 1.6 time = 1230
* CHECK dout0_10 vdout0_10ck122 = 1.6 time = 1230
* CHECK dout0_11 vdout0_11ck122 = 1.6 time = 1230
* CHECK dout0_12 vdout0_12ck122 = 1.6 time = 1230
* CHECK dout0_13 vdout0_13ck122 = 1.6 time = 1230
* CHECK dout0_14 vdout0_14ck122 = 1.6 time = 1230
* CHECK dout0_15 vdout0_15ck122 = 0 time = 1230
* CHECK dout0_16 vdout0_16ck122 = 0 time = 1230
* CHECK dout0_17 vdout0_17ck122 = 1.6 time = 1230
* CHECK dout0_18 vdout0_18ck122 = 1.6 time = 1230
* CHECK dout0_19 vdout0_19ck122 = 0 time = 1230
* CHECK dout0_20 vdout0_20ck122 = 1.6 time = 1230
* CHECK dout0_21 vdout0_21ck122 = 1.6 time = 1230
* CHECK dout0_22 vdout0_22ck122 = 0 time = 1230
* CHECK dout0_23 vdout0_23ck122 = 0 time = 1230
* CHECK dout0_24 vdout0_24ck122 = 1.6 time = 1230
* CHECK dout0_25 vdout0_25ck122 = 1.6 time = 1230
* CHECK dout0_26 vdout0_26ck122 = 0 time = 1230
* CHECK dout0_27 vdout0_27ck122 = 0 time = 1230
* CHECK dout0_28 vdout0_28ck122 = 0 time = 1230
* CHECK dout0_29 vdout0_29ck122 = 1.6 time = 1230
* CHECK dout0_30 vdout0_30ck122 = 0 time = 1230
* CHECK dout0_31 vdout0_31ck122 = 0 time = 1230
* CHECK dout0_32 vdout0_32ck122 = 0 time = 1230
* CHECK dout0_0 vdout0_0ck123 = 1.6 time = 1240
* CHECK dout0_1 vdout0_1ck123 = 1.6 time = 1240
* CHECK dout0_2 vdout0_2ck123 = 0 time = 1240
* CHECK dout0_3 vdout0_3ck123 = 0 time = 1240
* CHECK dout0_4 vdout0_4ck123 = 0 time = 1240
* CHECK dout0_5 vdout0_5ck123 = 0 time = 1240
* CHECK dout0_6 vdout0_6ck123 = 1.6 time = 1240
* CHECK dout0_7 vdout0_7ck123 = 0 time = 1240
* CHECK dout0_8 vdout0_8ck123 = 1.6 time = 1240
* CHECK dout0_9 vdout0_9ck123 = 1.6 time = 1240
* CHECK dout0_10 vdout0_10ck123 = 0 time = 1240
* CHECK dout0_11 vdout0_11ck123 = 1.6 time = 1240
* CHECK dout0_12 vdout0_12ck123 = 1.6 time = 1240
* CHECK dout0_13 vdout0_13ck123 = 1.6 time = 1240
* CHECK dout0_14 vdout0_14ck123 = 0 time = 1240
* CHECK dout0_15 vdout0_15ck123 = 0 time = 1240
* CHECK dout0_16 vdout0_16ck123 = 0 time = 1240
* CHECK dout0_17 vdout0_17ck123 = 0 time = 1240
* CHECK dout0_18 vdout0_18ck123 = 1.6 time = 1240
* CHECK dout0_19 vdout0_19ck123 = 1.6 time = 1240
* CHECK dout0_20 vdout0_20ck123 = 0 time = 1240
* CHECK dout0_21 vdout0_21ck123 = 0 time = 1240
* CHECK dout0_22 vdout0_22ck123 = 0 time = 1240
* CHECK dout0_23 vdout0_23ck123 = 1.6 time = 1240
* CHECK dout0_24 vdout0_24ck123 = 1.6 time = 1240
* CHECK dout0_25 vdout0_25ck123 = 1.6 time = 1240
* CHECK dout0_26 vdout0_26ck123 = 1.6 time = 1240
* CHECK dout0_27 vdout0_27ck123 = 0 time = 1240
* CHECK dout0_28 vdout0_28ck123 = 0 time = 1240
* CHECK dout0_29 vdout0_29ck123 = 0 time = 1240
* CHECK dout0_30 vdout0_30ck123 = 0 time = 1240
* CHECK dout0_31 vdout0_31ck123 = 0 time = 1240
* CHECK dout0_32 vdout0_32ck123 = 0 time = 1240
* CHECK dout1_0 vdout1_0ck123 = 1.6 time = 1240
* CHECK dout1_1 vdout1_1ck123 = 1.6 time = 1240
* CHECK dout1_2 vdout1_2ck123 = 1.6 time = 1240
* CHECK dout1_3 vdout1_3ck123 = 1.6 time = 1240
* CHECK dout1_4 vdout1_4ck123 = 1.6 time = 1240
* CHECK dout1_5 vdout1_5ck123 = 0 time = 1240
* CHECK dout1_6 vdout1_6ck123 = 0 time = 1240
* CHECK dout1_7 vdout1_7ck123 = 1.6 time = 1240
* CHECK dout1_8 vdout1_8ck123 = 1.6 time = 1240
* CHECK dout1_9 vdout1_9ck123 = 0 time = 1240
* CHECK dout1_10 vdout1_10ck123 = 0 time = 1240
* CHECK dout1_11 vdout1_11ck123 = 1.6 time = 1240
* CHECK dout1_12 vdout1_12ck123 = 0 time = 1240
* CHECK dout1_13 vdout1_13ck123 = 0 time = 1240
* CHECK dout1_14 vdout1_14ck123 = 0 time = 1240
* CHECK dout1_15 vdout1_15ck123 = 0 time = 1240
* CHECK dout1_16 vdout1_16ck123 = 1.6 time = 1240
* CHECK dout1_17 vdout1_17ck123 = 1.6 time = 1240
* CHECK dout1_18 vdout1_18ck123 = 1.6 time = 1240
* CHECK dout1_19 vdout1_19ck123 = 0 time = 1240
* CHECK dout1_20 vdout1_20ck123 = 0 time = 1240
* CHECK dout1_21 vdout1_21ck123 = 0 time = 1240
* CHECK dout1_22 vdout1_22ck123 = 1.6 time = 1240
* CHECK dout1_23 vdout1_23ck123 = 0 time = 1240
* CHECK dout1_24 vdout1_24ck123 = 1.6 time = 1240
* CHECK dout1_25 vdout1_25ck123 = 1.6 time = 1240
* CHECK dout1_26 vdout1_26ck123 = 1.6 time = 1240
* CHECK dout1_27 vdout1_27ck123 = 0 time = 1240
* CHECK dout1_28 vdout1_28ck123 = 1.6 time = 1240
* CHECK dout1_29 vdout1_29ck123 = 0 time = 1240
* CHECK dout1_30 vdout1_30ck123 = 1.6 time = 1240
* CHECK dout1_31 vdout1_31ck123 = 1.6 time = 1240
* CHECK dout1_32 vdout1_32ck123 = 0 time = 1240
* CHECK dout0_0 vdout0_0ck124 = 0 time = 1250
* CHECK dout0_1 vdout0_1ck124 = 1.6 time = 1250
* CHECK dout0_2 vdout0_2ck124 = 0 time = 1250
* CHECK dout0_3 vdout0_3ck124 = 0 time = 1250
* CHECK dout0_4 vdout0_4ck124 = 0 time = 1250
* CHECK dout0_5 vdout0_5ck124 = 0 time = 1250
* CHECK dout0_6 vdout0_6ck124 = 1.6 time = 1250
* CHECK dout0_7 vdout0_7ck124 = 0 time = 1250
* CHECK dout0_8 vdout0_8ck124 = 0 time = 1250
* CHECK dout0_9 vdout0_9ck124 = 1.6 time = 1250
* CHECK dout0_10 vdout0_10ck124 = 0 time = 1250
* CHECK dout0_11 vdout0_11ck124 = 1.6 time = 1250
* CHECK dout0_12 vdout0_12ck124 = 0 time = 1250
* CHECK dout0_13 vdout0_13ck124 = 1.6 time = 1250
* CHECK dout0_14 vdout0_14ck124 = 0 time = 1250
* CHECK dout0_15 vdout0_15ck124 = 1.6 time = 1250
* CHECK dout0_16 vdout0_16ck124 = 0 time = 1250
* CHECK dout0_17 vdout0_17ck124 = 1.6 time = 1250
* CHECK dout0_18 vdout0_18ck124 = 0 time = 1250
* CHECK dout0_19 vdout0_19ck124 = 0 time = 1250
* CHECK dout0_20 vdout0_20ck124 = 1.6 time = 1250
* CHECK dout0_21 vdout0_21ck124 = 1.6 time = 1250
* CHECK dout0_22 vdout0_22ck124 = 0 time = 1250
* CHECK dout0_23 vdout0_23ck124 = 0 time = 1250
* CHECK dout0_24 vdout0_24ck124 = 0 time = 1250
* CHECK dout0_25 vdout0_25ck124 = 1.6 time = 1250
* CHECK dout0_26 vdout0_26ck124 = 1.6 time = 1250
* CHECK dout0_27 vdout0_27ck124 = 1.6 time = 1250
* CHECK dout0_28 vdout0_28ck124 = 1.6 time = 1250
* CHECK dout0_29 vdout0_29ck124 = 0 time = 1250
* CHECK dout0_30 vdout0_30ck124 = 1.6 time = 1250
* CHECK dout0_31 vdout0_31ck124 = 1.6 time = 1250
* CHECK dout0_32 vdout0_32ck124 = 0 time = 1250
* CHECK dout1_0 vdout1_0ck126 = 0 time = 1270
* CHECK dout1_1 vdout1_1ck126 = 1.6 time = 1270
* CHECK dout1_2 vdout1_2ck126 = 0 time = 1270
* CHECK dout1_3 vdout1_3ck126 = 0 time = 1270
* CHECK dout1_4 vdout1_4ck126 = 0 time = 1270
* CHECK dout1_5 vdout1_5ck126 = 0 time = 1270
* CHECK dout1_6 vdout1_6ck126 = 1.6 time = 1270
* CHECK dout1_7 vdout1_7ck126 = 0 time = 1270
* CHECK dout1_8 vdout1_8ck126 = 0 time = 1270
* CHECK dout1_9 vdout1_9ck126 = 1.6 time = 1270
* CHECK dout1_10 vdout1_10ck126 = 0 time = 1270
* CHECK dout1_11 vdout1_11ck126 = 1.6 time = 1270
* CHECK dout1_12 vdout1_12ck126 = 0 time = 1270
* CHECK dout1_13 vdout1_13ck126 = 1.6 time = 1270
* CHECK dout1_14 vdout1_14ck126 = 0 time = 1270
* CHECK dout1_15 vdout1_15ck126 = 1.6 time = 1270
* CHECK dout1_16 vdout1_16ck126 = 0 time = 1270
* CHECK dout1_17 vdout1_17ck126 = 1.6 time = 1270
* CHECK dout1_18 vdout1_18ck126 = 0 time = 1270
* CHECK dout1_19 vdout1_19ck126 = 0 time = 1270
* CHECK dout1_20 vdout1_20ck126 = 1.6 time = 1270
* CHECK dout1_21 vdout1_21ck126 = 1.6 time = 1270
* CHECK dout1_22 vdout1_22ck126 = 0 time = 1270
* CHECK dout1_23 vdout1_23ck126 = 0 time = 1270
* CHECK dout1_24 vdout1_24ck126 = 0 time = 1270
* CHECK dout1_25 vdout1_25ck126 = 1.6 time = 1270
* CHECK dout1_26 vdout1_26ck126 = 1.6 time = 1270
* CHECK dout1_27 vdout1_27ck126 = 1.6 time = 1270
* CHECK dout1_28 vdout1_28ck126 = 1.6 time = 1270
* CHECK dout1_29 vdout1_29ck126 = 0 time = 1270
* CHECK dout1_30 vdout1_30ck126 = 1.6 time = 1270
* CHECK dout1_31 vdout1_31ck126 = 1.6 time = 1270
* CHECK dout1_32 vdout1_32ck126 = 0 time = 1270
* CHECK dout0_0 vdout0_0ck127 = 0 time = 1280
* CHECK dout0_1 vdout0_1ck127 = 1.6 time = 1280
* CHECK dout0_2 vdout0_2ck127 = 0 time = 1280
* CHECK dout0_3 vdout0_3ck127 = 0 time = 1280
* CHECK dout0_4 vdout0_4ck127 = 0 time = 1280
* CHECK dout0_5 vdout0_5ck127 = 0 time = 1280
* CHECK dout0_6 vdout0_6ck127 = 1.6 time = 1280
* CHECK dout0_7 vdout0_7ck127 = 0 time = 1280
* CHECK dout0_8 vdout0_8ck127 = 0 time = 1280
* CHECK dout0_9 vdout0_9ck127 = 1.6 time = 1280
* CHECK dout0_10 vdout0_10ck127 = 0 time = 1280
* CHECK dout0_11 vdout0_11ck127 = 1.6 time = 1280
* CHECK dout0_12 vdout0_12ck127 = 0 time = 1280
* CHECK dout0_13 vdout0_13ck127 = 1.6 time = 1280
* CHECK dout0_14 vdout0_14ck127 = 0 time = 1280
* CHECK dout0_15 vdout0_15ck127 = 1.6 time = 1280
* CHECK dout0_16 vdout0_16ck127 = 0 time = 1280
* CHECK dout0_17 vdout0_17ck127 = 1.6 time = 1280
* CHECK dout0_18 vdout0_18ck127 = 0 time = 1280
* CHECK dout0_19 vdout0_19ck127 = 0 time = 1280
* CHECK dout0_20 vdout0_20ck127 = 1.6 time = 1280
* CHECK dout0_21 vdout0_21ck127 = 1.6 time = 1280
* CHECK dout0_22 vdout0_22ck127 = 0 time = 1280
* CHECK dout0_23 vdout0_23ck127 = 0 time = 1280
* CHECK dout0_24 vdout0_24ck127 = 0 time = 1280
* CHECK dout0_25 vdout0_25ck127 = 1.6 time = 1280
* CHECK dout0_26 vdout0_26ck127 = 1.6 time = 1280
* CHECK dout0_27 vdout0_27ck127 = 1.6 time = 1280
* CHECK dout0_28 vdout0_28ck127 = 1.6 time = 1280
* CHECK dout0_29 vdout0_29ck127 = 0 time = 1280
* CHECK dout0_30 vdout0_30ck127 = 1.6 time = 1280
* CHECK dout0_31 vdout0_31ck127 = 1.6 time = 1280
* CHECK dout0_32 vdout0_32ck127 = 0 time = 1280
* CHECK dout1_0 vdout1_0ck131 = 1.6 time = 1320
* CHECK dout1_1 vdout1_1ck131 = 1.6 time = 1320
* CHECK dout1_2 vdout1_2ck131 = 0 time = 1320
* CHECK dout1_3 vdout1_3ck131 = 0 time = 1320
* CHECK dout1_4 vdout1_4ck131 = 0 time = 1320
* CHECK dout1_5 vdout1_5ck131 = 0 time = 1320
* CHECK dout1_6 vdout1_6ck131 = 1.6 time = 1320
* CHECK dout1_7 vdout1_7ck131 = 0 time = 1320
* CHECK dout1_8 vdout1_8ck131 = 1.6 time = 1320
* CHECK dout1_9 vdout1_9ck131 = 1.6 time = 1320
* CHECK dout1_10 vdout1_10ck131 = 0 time = 1320
* CHECK dout1_11 vdout1_11ck131 = 1.6 time = 1320
* CHECK dout1_12 vdout1_12ck131 = 1.6 time = 1320
* CHECK dout1_13 vdout1_13ck131 = 1.6 time = 1320
* CHECK dout1_14 vdout1_14ck131 = 0 time = 1320
* CHECK dout1_15 vdout1_15ck131 = 0 time = 1320
* CHECK dout1_16 vdout1_16ck131 = 0 time = 1320
* CHECK dout1_17 vdout1_17ck131 = 0 time = 1320
* CHECK dout1_18 vdout1_18ck131 = 1.6 time = 1320
* CHECK dout1_19 vdout1_19ck131 = 1.6 time = 1320
* CHECK dout1_20 vdout1_20ck131 = 0 time = 1320
* CHECK dout1_21 vdout1_21ck131 = 0 time = 1320
* CHECK dout1_22 vdout1_22ck131 = 0 time = 1320
* CHECK dout1_23 vdout1_23ck131 = 1.6 time = 1320
* CHECK dout1_24 vdout1_24ck131 = 1.6 time = 1320
* CHECK dout1_25 vdout1_25ck131 = 1.6 time = 1320
* CHECK dout1_26 vdout1_26ck131 = 1.6 time = 1320
* CHECK dout1_27 vdout1_27ck131 = 0 time = 1320
* CHECK dout1_28 vdout1_28ck131 = 0 time = 1320
* CHECK dout1_29 vdout1_29ck131 = 0 time = 1320
* CHECK dout1_30 vdout1_30ck131 = 0 time = 1320
* CHECK dout1_31 vdout1_31ck131 = 0 time = 1320
* CHECK dout1_32 vdout1_32ck131 = 0 time = 1320
* CHECK dout0_0 vdout0_0ck132 = 1.6 time = 1330
* CHECK dout0_1 vdout0_1ck132 = 1.6 time = 1330
* CHECK dout0_2 vdout0_2ck132 = 1.6 time = 1330
* CHECK dout0_3 vdout0_3ck132 = 1.6 time = 1330
* CHECK dout0_4 vdout0_4ck132 = 0 time = 1330
* CHECK dout0_5 vdout0_5ck132 = 1.6 time = 1330
* CHECK dout0_6 vdout0_6ck132 = 1.6 time = 1330
* CHECK dout0_7 vdout0_7ck132 = 0 time = 1330
* CHECK dout0_8 vdout0_8ck132 = 0 time = 1330
* CHECK dout0_9 vdout0_9ck132 = 0 time = 1330
* CHECK dout0_10 vdout0_10ck132 = 1.6 time = 1330
* CHECK dout0_11 vdout0_11ck132 = 1.6 time = 1330
* CHECK dout0_12 vdout0_12ck132 = 0 time = 1330
* CHECK dout0_13 vdout0_13ck132 = 1.6 time = 1330
* CHECK dout0_14 vdout0_14ck132 = 0 time = 1330
* CHECK dout0_15 vdout0_15ck132 = 1.6 time = 1330
* CHECK dout0_16 vdout0_16ck132 = 1.6 time = 1330
* CHECK dout0_17 vdout0_17ck132 = 0 time = 1330
* CHECK dout0_18 vdout0_18ck132 = 1.6 time = 1330
* CHECK dout0_19 vdout0_19ck132 = 1.6 time = 1330
* CHECK dout0_20 vdout0_20ck132 = 0 time = 1330
* CHECK dout0_21 vdout0_21ck132 = 1.6 time = 1330
* CHECK dout0_22 vdout0_22ck132 = 1.6 time = 1330
* CHECK dout0_23 vdout0_23ck132 = 0 time = 1330
* CHECK dout0_24 vdout0_24ck132 = 0 time = 1330
* CHECK dout0_25 vdout0_25ck132 = 1.6 time = 1330
* CHECK dout0_26 vdout0_26ck132 = 1.6 time = 1330
* CHECK dout0_27 vdout0_27ck132 = 0 time = 1330
* CHECK dout0_28 vdout0_28ck132 = 1.6 time = 1330
* CHECK dout0_29 vdout0_29ck132 = 1.6 time = 1330
* CHECK dout0_30 vdout0_30ck132 = 0 time = 1330
* CHECK dout0_31 vdout0_31ck132 = 1.6 time = 1330
* CHECK dout0_32 vdout0_32ck132 = 0 time = 1330
* CHECK dout1_0 vdout1_0ck132 = 1.6 time = 1330
* CHECK dout1_1 vdout1_1ck132 = 1.6 time = 1330
* CHECK dout1_2 vdout1_2ck132 = 0 time = 1330
* CHECK dout1_3 vdout1_3ck132 = 0 time = 1330
* CHECK dout1_4 vdout1_4ck132 = 0 time = 1330
* CHECK dout1_5 vdout1_5ck132 = 0 time = 1330
* CHECK dout1_6 vdout1_6ck132 = 1.6 time = 1330
* CHECK dout1_7 vdout1_7ck132 = 0 time = 1330
* CHECK dout1_8 vdout1_8ck132 = 1.6 time = 1330
* CHECK dout1_9 vdout1_9ck132 = 1.6 time = 1330
* CHECK dout1_10 vdout1_10ck132 = 0 time = 1330
* CHECK dout1_11 vdout1_11ck132 = 1.6 time = 1330
* CHECK dout1_12 vdout1_12ck132 = 1.6 time = 1330
* CHECK dout1_13 vdout1_13ck132 = 1.6 time = 1330
* CHECK dout1_14 vdout1_14ck132 = 0 time = 1330
* CHECK dout1_15 vdout1_15ck132 = 0 time = 1330
* CHECK dout1_16 vdout1_16ck132 = 0 time = 1330
* CHECK dout1_17 vdout1_17ck132 = 0 time = 1330
* CHECK dout1_18 vdout1_18ck132 = 1.6 time = 1330
* CHECK dout1_19 vdout1_19ck132 = 1.6 time = 1330
* CHECK dout1_20 vdout1_20ck132 = 0 time = 1330
* CHECK dout1_21 vdout1_21ck132 = 0 time = 1330
* CHECK dout1_22 vdout1_22ck132 = 0 time = 1330
* CHECK dout1_23 vdout1_23ck132 = 1.6 time = 1330
* CHECK dout1_24 vdout1_24ck132 = 1.6 time = 1330
* CHECK dout1_25 vdout1_25ck132 = 1.6 time = 1330
* CHECK dout1_26 vdout1_26ck132 = 1.6 time = 1330
* CHECK dout1_27 vdout1_27ck132 = 0 time = 1330
* CHECK dout1_28 vdout1_28ck132 = 0 time = 1330
* CHECK dout1_29 vdout1_29ck132 = 0 time = 1330
* CHECK dout1_30 vdout1_30ck132 = 0 time = 1330
* CHECK dout1_31 vdout1_31ck132 = 0 time = 1330
* CHECK dout1_32 vdout1_32ck132 = 0 time = 1330
* CHECK dout0_0 vdout0_0ck134 = 1.6 time = 1350
* CHECK dout0_1 vdout0_1ck134 = 1.6 time = 1350
* CHECK dout0_2 vdout0_2ck134 = 0 time = 1350
* CHECK dout0_3 vdout0_3ck134 = 0 time = 1350
* CHECK dout0_4 vdout0_4ck134 = 0 time = 1350
* CHECK dout0_5 vdout0_5ck134 = 0 time = 1350
* CHECK dout0_6 vdout0_6ck134 = 1.6 time = 1350
* CHECK dout0_7 vdout0_7ck134 = 0 time = 1350
* CHECK dout0_8 vdout0_8ck134 = 1.6 time = 1350
* CHECK dout0_9 vdout0_9ck134 = 1.6 time = 1350
* CHECK dout0_10 vdout0_10ck134 = 0 time = 1350
* CHECK dout0_11 vdout0_11ck134 = 1.6 time = 1350
* CHECK dout0_12 vdout0_12ck134 = 1.6 time = 1350
* CHECK dout0_13 vdout0_13ck134 = 1.6 time = 1350
* CHECK dout0_14 vdout0_14ck134 = 0 time = 1350
* CHECK dout0_15 vdout0_15ck134 = 0 time = 1350
* CHECK dout0_16 vdout0_16ck134 = 0 time = 1350
* CHECK dout0_17 vdout0_17ck134 = 0 time = 1350
* CHECK dout0_18 vdout0_18ck134 = 1.6 time = 1350
* CHECK dout0_19 vdout0_19ck134 = 1.6 time = 1350
* CHECK dout0_20 vdout0_20ck134 = 0 time = 1350
* CHECK dout0_21 vdout0_21ck134 = 0 time = 1350
* CHECK dout0_22 vdout0_22ck134 = 0 time = 1350
* CHECK dout0_23 vdout0_23ck134 = 1.6 time = 1350
* CHECK dout0_24 vdout0_24ck134 = 1.6 time = 1350
* CHECK dout0_25 vdout0_25ck134 = 1.6 time = 1350
* CHECK dout0_26 vdout0_26ck134 = 1.6 time = 1350
* CHECK dout0_27 vdout0_27ck134 = 0 time = 1350
* CHECK dout0_28 vdout0_28ck134 = 0 time = 1350
* CHECK dout0_29 vdout0_29ck134 = 0 time = 1350
* CHECK dout0_30 vdout0_30ck134 = 0 time = 1350
* CHECK dout0_31 vdout0_31ck134 = 0 time = 1350
* CHECK dout0_32 vdout0_32ck134 = 0 time = 1350
* CHECK dout1_0 vdout1_0ck134 = 1.6 time = 1350
* CHECK dout1_1 vdout1_1ck134 = 1.6 time = 1350
* CHECK dout1_2 vdout1_2ck134 = 1.6 time = 1350
* CHECK dout1_3 vdout1_3ck134 = 1.6 time = 1350
* CHECK dout1_4 vdout1_4ck134 = 1.6 time = 1350
* CHECK dout1_5 vdout1_5ck134 = 0 time = 1350
* CHECK dout1_6 vdout1_6ck134 = 0 time = 1350
* CHECK dout1_7 vdout1_7ck134 = 0 time = 1350
* CHECK dout1_8 vdout1_8ck134 = 1.6 time = 1350
* CHECK dout1_9 vdout1_9ck134 = 0 time = 1350
* CHECK dout1_10 vdout1_10ck134 = 0 time = 1350
* CHECK dout1_11 vdout1_11ck134 = 1.6 time = 1350
* CHECK dout1_12 vdout1_12ck134 = 0 time = 1350
* CHECK dout1_13 vdout1_13ck134 = 1.6 time = 1350
* CHECK dout1_14 vdout1_14ck134 = 1.6 time = 1350
* CHECK dout1_15 vdout1_15ck134 = 1.6 time = 1350
* CHECK dout1_16 vdout1_16ck134 = 0 time = 1350
* CHECK dout1_17 vdout1_17ck134 = 1.6 time = 1350
* CHECK dout1_18 vdout1_18ck134 = 1.6 time = 1350
* CHECK dout1_19 vdout1_19ck134 = 0 time = 1350
* CHECK dout1_20 vdout1_20ck134 = 0 time = 1350
* CHECK dout1_21 vdout1_21ck134 = 1.6 time = 1350
* CHECK dout1_22 vdout1_22ck134 = 0 time = 1350
* CHECK dout1_23 vdout1_23ck134 = 0 time = 1350
* CHECK dout1_24 vdout1_24ck134 = 0 time = 1350
* CHECK dout1_25 vdout1_25ck134 = 0 time = 1350
* CHECK dout1_26 vdout1_26ck134 = 1.6 time = 1350
* CHECK dout1_27 vdout1_27ck134 = 0 time = 1350
* CHECK dout1_28 vdout1_28ck134 = 1.6 time = 1350
* CHECK dout1_29 vdout1_29ck134 = 0 time = 1350
* CHECK dout1_30 vdout1_30ck134 = 1.6 time = 1350
* CHECK dout1_31 vdout1_31ck134 = 1.6 time = 1350
* CHECK dout1_32 vdout1_32ck134 = 0 time = 1350
* CHECK dout0_0 vdout0_0ck137 = 1.6 time = 1380
* CHECK dout0_1 vdout0_1ck137 = 1.6 time = 1380
* CHECK dout0_2 vdout0_2ck137 = 0 time = 1380
* CHECK dout0_3 vdout0_3ck137 = 0 time = 1380
* CHECK dout0_4 vdout0_4ck137 = 0 time = 1380
* CHECK dout0_5 vdout0_5ck137 = 0 time = 1380
* CHECK dout0_6 vdout0_6ck137 = 1.6 time = 1380
* CHECK dout0_7 vdout0_7ck137 = 0 time = 1380
* CHECK dout0_8 vdout0_8ck137 = 1.6 time = 1380
* CHECK dout0_9 vdout0_9ck137 = 1.6 time = 1380
* CHECK dout0_10 vdout0_10ck137 = 0 time = 1380
* CHECK dout0_11 vdout0_11ck137 = 1.6 time = 1380
* CHECK dout0_12 vdout0_12ck137 = 1.6 time = 1380
* CHECK dout0_13 vdout0_13ck137 = 1.6 time = 1380
* CHECK dout0_14 vdout0_14ck137 = 0 time = 1380
* CHECK dout0_15 vdout0_15ck137 = 0 time = 1380
* CHECK dout0_16 vdout0_16ck137 = 0 time = 1380
* CHECK dout0_17 vdout0_17ck137 = 0 time = 1380
* CHECK dout0_18 vdout0_18ck137 = 1.6 time = 1380
* CHECK dout0_19 vdout0_19ck137 = 1.6 time = 1380
* CHECK dout0_20 vdout0_20ck137 = 0 time = 1380
* CHECK dout0_21 vdout0_21ck137 = 0 time = 1380
* CHECK dout0_22 vdout0_22ck137 = 0 time = 1380
* CHECK dout0_23 vdout0_23ck137 = 1.6 time = 1380
* CHECK dout0_24 vdout0_24ck137 = 1.6 time = 1380
* CHECK dout0_25 vdout0_25ck137 = 1.6 time = 1380
* CHECK dout0_26 vdout0_26ck137 = 1.6 time = 1380
* CHECK dout0_27 vdout0_27ck137 = 0 time = 1380
* CHECK dout0_28 vdout0_28ck137 = 0 time = 1380
* CHECK dout0_29 vdout0_29ck137 = 0 time = 1380
* CHECK dout0_30 vdout0_30ck137 = 0 time = 1380
* CHECK dout0_31 vdout0_31ck137 = 0 time = 1380
* CHECK dout0_32 vdout0_32ck137 = 0 time = 1380
* CHECK dout0_0 vdout0_0ck139 = 1.6 time = 1400
* CHECK dout0_1 vdout0_1ck139 = 1.6 time = 1400
* CHECK dout0_2 vdout0_2ck139 = 1.6 time = 1400
* CHECK dout0_3 vdout0_3ck139 = 0 time = 1400
* CHECK dout0_4 vdout0_4ck139 = 0 time = 1400
* CHECK dout0_5 vdout0_5ck139 = 0 time = 1400
* CHECK dout0_6 vdout0_6ck139 = 0 time = 1400
* CHECK dout0_7 vdout0_7ck139 = 1.6 time = 1400
* CHECK dout0_8 vdout0_8ck139 = 0 time = 1400
* CHECK dout0_9 vdout0_9ck139 = 1.6 time = 1400
* CHECK dout0_10 vdout0_10ck139 = 0 time = 1400
* CHECK dout0_11 vdout0_11ck139 = 0 time = 1400
* CHECK dout0_12 vdout0_12ck139 = 1.6 time = 1400
* CHECK dout0_13 vdout0_13ck139 = 1.6 time = 1400
* CHECK dout0_14 vdout0_14ck139 = 1.6 time = 1400
* CHECK dout0_15 vdout0_15ck139 = 0 time = 1400
* CHECK dout0_16 vdout0_16ck139 = 0 time = 1400
* CHECK dout0_17 vdout0_17ck139 = 1.6 time = 1400
* CHECK dout0_18 vdout0_18ck139 = 1.6 time = 1400
* CHECK dout0_19 vdout0_19ck139 = 1.6 time = 1400
* CHECK dout0_20 vdout0_20ck139 = 1.6 time = 1400
* CHECK dout0_21 vdout0_21ck139 = 0 time = 1400
* CHECK dout0_22 vdout0_22ck139 = 0 time = 1400
* CHECK dout0_23 vdout0_23ck139 = 0 time = 1400
* CHECK dout0_24 vdout0_24ck139 = 1.6 time = 1400
* CHECK dout0_25 vdout0_25ck139 = 1.6 time = 1400
* CHECK dout0_26 vdout0_26ck139 = 0 time = 1400
* CHECK dout0_27 vdout0_27ck139 = 0 time = 1400
* CHECK dout0_28 vdout0_28ck139 = 0 time = 1400
* CHECK dout0_29 vdout0_29ck139 = 0 time = 1400
* CHECK dout0_30 vdout0_30ck139 = 1.6 time = 1400
* CHECK dout0_31 vdout0_31ck139 = 0 time = 1400
* CHECK dout0_32 vdout0_32ck139 = 0 time = 1400
* CHECK dout1_0 vdout1_0ck139 = 1.6 time = 1400
* CHECK dout1_1 vdout1_1ck139 = 1.6 time = 1400
* CHECK dout1_2 vdout1_2ck139 = 0 time = 1400
* CHECK dout1_3 vdout1_3ck139 = 0 time = 1400
* CHECK dout1_4 vdout1_4ck139 = 0 time = 1400
* CHECK dout1_5 vdout1_5ck139 = 0 time = 1400
* CHECK dout1_6 vdout1_6ck139 = 1.6 time = 1400
* CHECK dout1_7 vdout1_7ck139 = 0 time = 1400
* CHECK dout1_8 vdout1_8ck139 = 1.6 time = 1400
* CHECK dout1_9 vdout1_9ck139 = 1.6 time = 1400
* CHECK dout1_10 vdout1_10ck139 = 0 time = 1400
* CHECK dout1_11 vdout1_11ck139 = 1.6 time = 1400
* CHECK dout1_12 vdout1_12ck139 = 1.6 time = 1400
* CHECK dout1_13 vdout1_13ck139 = 1.6 time = 1400
* CHECK dout1_14 vdout1_14ck139 = 0 time = 1400
* CHECK dout1_15 vdout1_15ck139 = 0 time = 1400
* CHECK dout1_16 vdout1_16ck139 = 0 time = 1400
* CHECK dout1_17 vdout1_17ck139 = 0 time = 1400
* CHECK dout1_18 vdout1_18ck139 = 1.6 time = 1400
* CHECK dout1_19 vdout1_19ck139 = 1.6 time = 1400
* CHECK dout1_20 vdout1_20ck139 = 0 time = 1400
* CHECK dout1_21 vdout1_21ck139 = 0 time = 1400
* CHECK dout1_22 vdout1_22ck139 = 0 time = 1400
* CHECK dout1_23 vdout1_23ck139 = 1.6 time = 1400
* CHECK dout1_24 vdout1_24ck139 = 1.6 time = 1400
* CHECK dout1_25 vdout1_25ck139 = 1.6 time = 1400
* CHECK dout1_26 vdout1_26ck139 = 1.6 time = 1400
* CHECK dout1_27 vdout1_27ck139 = 0 time = 1400
* CHECK dout1_28 vdout1_28ck139 = 0 time = 1400
* CHECK dout1_29 vdout1_29ck139 = 0 time = 1400
* CHECK dout1_30 vdout1_30ck139 = 0 time = 1400
* CHECK dout1_31 vdout1_31ck139 = 0 time = 1400
* CHECK dout1_32 vdout1_32ck139 = 0 time = 1400
* CHECK dout1_0 vdout1_0ck140 = 1.6 time = 1410
* CHECK dout1_1 vdout1_1ck140 = 1.6 time = 1410
* CHECK dout1_2 vdout1_2ck140 = 1.6 time = 1410
* CHECK dout1_3 vdout1_3ck140 = 1.6 time = 1410
* CHECK dout1_4 vdout1_4ck140 = 0 time = 1410
* CHECK dout1_5 vdout1_5ck140 = 1.6 time = 1410
* CHECK dout1_6 vdout1_6ck140 = 1.6 time = 1410
* CHECK dout1_7 vdout1_7ck140 = 0 time = 1410
* CHECK dout1_8 vdout1_8ck140 = 0 time = 1410
* CHECK dout1_9 vdout1_9ck140 = 0 time = 1410
* CHECK dout1_10 vdout1_10ck140 = 1.6 time = 1410
* CHECK dout1_11 vdout1_11ck140 = 1.6 time = 1410
* CHECK dout1_12 vdout1_12ck140 = 0 time = 1410
* CHECK dout1_13 vdout1_13ck140 = 1.6 time = 1410
* CHECK dout1_14 vdout1_14ck140 = 0 time = 1410
* CHECK dout1_15 vdout1_15ck140 = 1.6 time = 1410
* CHECK dout1_16 vdout1_16ck140 = 1.6 time = 1410
* CHECK dout1_17 vdout1_17ck140 = 0 time = 1410
* CHECK dout1_18 vdout1_18ck140 = 1.6 time = 1410
* CHECK dout1_19 vdout1_19ck140 = 1.6 time = 1410
* CHECK dout1_20 vdout1_20ck140 = 0 time = 1410
* CHECK dout1_21 vdout1_21ck140 = 1.6 time = 1410
* CHECK dout1_22 vdout1_22ck140 = 1.6 time = 1410
* CHECK dout1_23 vdout1_23ck140 = 0 time = 1410
* CHECK dout1_24 vdout1_24ck140 = 0 time = 1410
* CHECK dout1_25 vdout1_25ck140 = 1.6 time = 1410
* CHECK dout1_26 vdout1_26ck140 = 1.6 time = 1410
* CHECK dout1_27 vdout1_27ck140 = 0 time = 1410
* CHECK dout1_28 vdout1_28ck140 = 1.6 time = 1410
* CHECK dout1_29 vdout1_29ck140 = 1.6 time = 1410
* CHECK dout1_30 vdout1_30ck140 = 0 time = 1410
* CHECK dout1_31 vdout1_31ck140 = 1.6 time = 1410
* CHECK dout1_32 vdout1_32ck140 = 0 time = 1410
* CHECK dout1_0 vdout1_0ck142 = 1.6 time = 1430
* CHECK dout1_1 vdout1_1ck142 = 1.6 time = 1430
* CHECK dout1_2 vdout1_2ck142 = 1.6 time = 1430
* CHECK dout1_3 vdout1_3ck142 = 0 time = 1430
* CHECK dout1_4 vdout1_4ck142 = 0 time = 1430
* CHECK dout1_5 vdout1_5ck142 = 0 time = 1430
* CHECK dout1_6 vdout1_6ck142 = 0 time = 1430
* CHECK dout1_7 vdout1_7ck142 = 1.6 time = 1430
* CHECK dout1_8 vdout1_8ck142 = 0 time = 1430
* CHECK dout1_9 vdout1_9ck142 = 1.6 time = 1430
* CHECK dout1_10 vdout1_10ck142 = 0 time = 1430
* CHECK dout1_11 vdout1_11ck142 = 0 time = 1430
* CHECK dout1_12 vdout1_12ck142 = 1.6 time = 1430
* CHECK dout1_13 vdout1_13ck142 = 1.6 time = 1430
* CHECK dout1_14 vdout1_14ck142 = 1.6 time = 1430
* CHECK dout1_15 vdout1_15ck142 = 0 time = 1430
* CHECK dout1_16 vdout1_16ck142 = 0 time = 1430
* CHECK dout1_17 vdout1_17ck142 = 1.6 time = 1430
* CHECK dout1_18 vdout1_18ck142 = 1.6 time = 1430
* CHECK dout1_19 vdout1_19ck142 = 1.6 time = 1430
* CHECK dout1_20 vdout1_20ck142 = 1.6 time = 1430
* CHECK dout1_21 vdout1_21ck142 = 0 time = 1430
* CHECK dout1_22 vdout1_22ck142 = 0 time = 1430
* CHECK dout1_23 vdout1_23ck142 = 0 time = 1430
* CHECK dout1_24 vdout1_24ck142 = 1.6 time = 1430
* CHECK dout1_25 vdout1_25ck142 = 1.6 time = 1430
* CHECK dout1_26 vdout1_26ck142 = 0 time = 1430
* CHECK dout1_27 vdout1_27ck142 = 0 time = 1430
* CHECK dout1_28 vdout1_28ck142 = 0 time = 1430
* CHECK dout1_29 vdout1_29ck142 = 0 time = 1430
* CHECK dout1_30 vdout1_30ck142 = 1.6 time = 1430
* CHECK dout1_31 vdout1_31ck142 = 0 time = 1430
* CHECK dout1_32 vdout1_32ck142 = 0 time = 1430
* CHECK dout1_0 vdout1_0ck143 = 1.6 time = 1440
* CHECK dout1_1 vdout1_1ck143 = 1.6 time = 1440
* CHECK dout1_2 vdout1_2ck143 = 0 time = 1440
* CHECK dout1_3 vdout1_3ck143 = 0 time = 1440
* CHECK dout1_4 vdout1_4ck143 = 0 time = 1440
* CHECK dout1_5 vdout1_5ck143 = 1.6 time = 1440
* CHECK dout1_6 vdout1_6ck143 = 0 time = 1440
* CHECK dout1_7 vdout1_7ck143 = 1.6 time = 1440
* CHECK dout1_8 vdout1_8ck143 = 1.6 time = 1440
* CHECK dout1_9 vdout1_9ck143 = 1.6 time = 1440
* CHECK dout1_10 vdout1_10ck143 = 0 time = 1440
* CHECK dout1_11 vdout1_11ck143 = 1.6 time = 1440
* CHECK dout1_12 vdout1_12ck143 = 1.6 time = 1440
* CHECK dout1_13 vdout1_13ck143 = 0 time = 1440
* CHECK dout1_14 vdout1_14ck143 = 1.6 time = 1440
* CHECK dout1_15 vdout1_15ck143 = 0 time = 1440
* CHECK dout1_16 vdout1_16ck143 = 1.6 time = 1440
* CHECK dout1_17 vdout1_17ck143 = 0 time = 1440
* CHECK dout1_18 vdout1_18ck143 = 0 time = 1440
* CHECK dout1_19 vdout1_19ck143 = 1.6 time = 1440
* CHECK dout1_20 vdout1_20ck143 = 1.6 time = 1440
* CHECK dout1_21 vdout1_21ck143 = 0 time = 1440
* CHECK dout1_22 vdout1_22ck143 = 0 time = 1440
* CHECK dout1_23 vdout1_23ck143 = 0 time = 1440
* CHECK dout1_24 vdout1_24ck143 = 0 time = 1440
* CHECK dout1_25 vdout1_25ck143 = 1.6 time = 1440
* CHECK dout1_26 vdout1_26ck143 = 0 time = 1440
* CHECK dout1_27 vdout1_27ck143 = 0 time = 1440
* CHECK dout1_28 vdout1_28ck143 = 1.6 time = 1440
* CHECK dout1_29 vdout1_29ck143 = 1.6 time = 1440
* CHECK dout1_30 vdout1_30ck143 = 1.6 time = 1440
* CHECK dout1_31 vdout1_31ck143 = 1.6 time = 1440
* CHECK dout1_32 vdout1_32ck143 = 0 time = 1440
* CHECK dout1_0 vdout1_0ck144 = 0 time = 1450
* CHECK dout1_1 vdout1_1ck144 = 1.6 time = 1450
* CHECK dout1_2 vdout1_2ck144 = 0 time = 1450
* CHECK dout1_3 vdout1_3ck144 = 0 time = 1450
* CHECK dout1_4 vdout1_4ck144 = 1.6 time = 1450
* CHECK dout1_5 vdout1_5ck144 = 1.6 time = 1450
* CHECK dout1_6 vdout1_6ck144 = 0 time = 1450
* CHECK dout1_7 vdout1_7ck144 = 0 time = 1450
* CHECK dout1_8 vdout1_8ck144 = 0 time = 1450
* CHECK dout1_9 vdout1_9ck144 = 1.6 time = 1450
* CHECK dout1_10 vdout1_10ck144 = 0 time = 1450
* CHECK dout1_11 vdout1_11ck144 = 1.6 time = 1450
* CHECK dout1_12 vdout1_12ck144 = 0 time = 1450
* CHECK dout1_13 vdout1_13ck144 = 1.6 time = 1450
* CHECK dout1_14 vdout1_14ck144 = 1.6 time = 1450
* CHECK dout1_15 vdout1_15ck144 = 0 time = 1450
* CHECK dout1_16 vdout1_16ck144 = 1.6 time = 1450
* CHECK dout1_17 vdout1_17ck144 = 0 time = 1450
* CHECK dout1_18 vdout1_18ck144 = 1.6 time = 1450
* CHECK dout1_19 vdout1_19ck144 = 0 time = 1450
* CHECK dout1_20 vdout1_20ck144 = 0 time = 1450
* CHECK dout1_21 vdout1_21ck144 = 0 time = 1450
* CHECK dout1_22 vdout1_22ck144 = 1.6 time = 1450
* CHECK dout1_23 vdout1_23ck144 = 0 time = 1450
* CHECK dout1_24 vdout1_24ck144 = 1.6 time = 1450
* CHECK dout1_25 vdout1_25ck144 = 1.6 time = 1450
* CHECK dout1_26 vdout1_26ck144 = 0 time = 1450
* CHECK dout1_27 vdout1_27ck144 = 1.6 time = 1450
* CHECK dout1_28 vdout1_28ck144 = 0 time = 1450
* CHECK dout1_29 vdout1_29ck144 = 0 time = 1450
* CHECK dout1_30 vdout1_30ck144 = 0 time = 1450
* CHECK dout1_31 vdout1_31ck144 = 0 time = 1450
* CHECK dout1_32 vdout1_32ck144 = 0 time = 1450
* CHECK dout1_0 vdout1_0ck146 = 1.6 time = 1470
* CHECK dout1_1 vdout1_1ck146 = 0 time = 1470
* CHECK dout1_2 vdout1_2ck146 = 1.6 time = 1470
* CHECK dout1_3 vdout1_3ck146 = 1.6 time = 1470
* CHECK dout1_4 vdout1_4ck146 = 0 time = 1470
* CHECK dout1_5 vdout1_5ck146 = 1.6 time = 1470
* CHECK dout1_6 vdout1_6ck146 = 1.6 time = 1470
* CHECK dout1_7 vdout1_7ck146 = 0 time = 1470
* CHECK dout1_8 vdout1_8ck146 = 0 time = 1470
* CHECK dout1_9 vdout1_9ck146 = 0 time = 1470
* CHECK dout1_10 vdout1_10ck146 = 0 time = 1470
* CHECK dout1_11 vdout1_11ck146 = 0 time = 1470
* CHECK dout1_12 vdout1_12ck146 = 1.6 time = 1470
* CHECK dout1_13 vdout1_13ck146 = 1.6 time = 1470
* CHECK dout1_14 vdout1_14ck146 = 1.6 time = 1470
* CHECK dout1_15 vdout1_15ck146 = 1.6 time = 1470
* CHECK dout1_16 vdout1_16ck146 = 1.6 time = 1470
* CHECK dout1_17 vdout1_17ck146 = 0 time = 1470
* CHECK dout1_18 vdout1_18ck146 = 1.6 time = 1470
* CHECK dout1_19 vdout1_19ck146 = 0 time = 1470
* CHECK dout1_20 vdout1_20ck146 = 0 time = 1470
* CHECK dout1_21 vdout1_21ck146 = 1.6 time = 1470
* CHECK dout1_22 vdout1_22ck146 = 0 time = 1470
* CHECK dout1_23 vdout1_23ck146 = 1.6 time = 1470
* CHECK dout1_24 vdout1_24ck146 = 0 time = 1470
* CHECK dout1_25 vdout1_25ck146 = 1.6 time = 1470
* CHECK dout1_26 vdout1_26ck146 = 0 time = 1470
* CHECK dout1_27 vdout1_27ck146 = 1.6 time = 1470
* CHECK dout1_28 vdout1_28ck146 = 0 time = 1470
* CHECK dout1_29 vdout1_29ck146 = 1.6 time = 1470
* CHECK dout1_30 vdout1_30ck146 = 0 time = 1470
* CHECK dout1_31 vdout1_31ck146 = 0 time = 1470
* CHECK dout1_32 vdout1_32ck146 = 0 time = 1470
* CHECK dout0_0 vdout0_0ck148 = 1.6 time = 1490
* CHECK dout0_1 vdout0_1ck148 = 0 time = 1490
* CHECK dout0_2 vdout0_2ck148 = 1.6 time = 1490
* CHECK dout0_3 vdout0_3ck148 = 1.6 time = 1490
* CHECK dout0_4 vdout0_4ck148 = 0 time = 1490
* CHECK dout0_5 vdout0_5ck148 = 1.6 time = 1490
* CHECK dout0_6 vdout0_6ck148 = 1.6 time = 1490
* CHECK dout0_7 vdout0_7ck148 = 0 time = 1490
* CHECK dout0_8 vdout0_8ck148 = 0 time = 1490
* CHECK dout0_9 vdout0_9ck148 = 0 time = 1490
* CHECK dout0_10 vdout0_10ck148 = 0 time = 1490
* CHECK dout0_11 vdout0_11ck148 = 0 time = 1490
* CHECK dout0_12 vdout0_12ck148 = 1.6 time = 1490
* CHECK dout0_13 vdout0_13ck148 = 1.6 time = 1490
* CHECK dout0_14 vdout0_14ck148 = 1.6 time = 1490
* CHECK dout0_15 vdout0_15ck148 = 1.6 time = 1490
* CHECK dout0_16 vdout0_16ck148 = 1.6 time = 1490
* CHECK dout0_17 vdout0_17ck148 = 0 time = 1490
* CHECK dout0_18 vdout0_18ck148 = 1.6 time = 1490
* CHECK dout0_19 vdout0_19ck148 = 0 time = 1490
* CHECK dout0_20 vdout0_20ck148 = 0 time = 1490
* CHECK dout0_21 vdout0_21ck148 = 1.6 time = 1490
* CHECK dout0_22 vdout0_22ck148 = 0 time = 1490
* CHECK dout0_23 vdout0_23ck148 = 1.6 time = 1490
* CHECK dout0_24 vdout0_24ck148 = 0 time = 1490
* CHECK dout0_25 vdout0_25ck148 = 1.6 time = 1490
* CHECK dout0_26 vdout0_26ck148 = 0 time = 1490
* CHECK dout0_27 vdout0_27ck148 = 1.6 time = 1490
* CHECK dout0_28 vdout0_28ck148 = 0 time = 1490
* CHECK dout0_29 vdout0_29ck148 = 1.6 time = 1490
* CHECK dout0_30 vdout0_30ck148 = 0 time = 1490
* CHECK dout0_31 vdout0_31ck148 = 0 time = 1490
* CHECK dout0_32 vdout0_32ck148 = 0 time = 1490
* CHECK dout1_0 vdout1_0ck148 = 1.6 time = 1490
* CHECK dout1_1 vdout1_1ck148 = 1.6 time = 1490
* CHECK dout1_2 vdout1_2ck148 = 0 time = 1490
* CHECK dout1_3 vdout1_3ck148 = 0 time = 1490
* CHECK dout1_4 vdout1_4ck148 = 0 time = 1490
* CHECK dout1_5 vdout1_5ck148 = 1.6 time = 1490
* CHECK dout1_6 vdout1_6ck148 = 0 time = 1490
* CHECK dout1_7 vdout1_7ck148 = 1.6 time = 1490
* CHECK dout1_8 vdout1_8ck148 = 1.6 time = 1490
* CHECK dout1_9 vdout1_9ck148 = 1.6 time = 1490
* CHECK dout1_10 vdout1_10ck148 = 0 time = 1490
* CHECK dout1_11 vdout1_11ck148 = 1.6 time = 1490
* CHECK dout1_12 vdout1_12ck148 = 1.6 time = 1490
* CHECK dout1_13 vdout1_13ck148 = 0 time = 1490
* CHECK dout1_14 vdout1_14ck148 = 1.6 time = 1490
* CHECK dout1_15 vdout1_15ck148 = 0 time = 1490
* CHECK dout1_16 vdout1_16ck148 = 1.6 time = 1490
* CHECK dout1_17 vdout1_17ck148 = 0 time = 1490
* CHECK dout1_18 vdout1_18ck148 = 0 time = 1490
* CHECK dout1_19 vdout1_19ck148 = 1.6 time = 1490
* CHECK dout1_20 vdout1_20ck148 = 1.6 time = 1490
* CHECK dout1_21 vdout1_21ck148 = 0 time = 1490
* CHECK dout1_22 vdout1_22ck148 = 0 time = 1490
* CHECK dout1_23 vdout1_23ck148 = 0 time = 1490
* CHECK dout1_24 vdout1_24ck148 = 0 time = 1490
* CHECK dout1_25 vdout1_25ck148 = 1.6 time = 1490
* CHECK dout1_26 vdout1_26ck148 = 0 time = 1490
* CHECK dout1_27 vdout1_27ck148 = 0 time = 1490
* CHECK dout1_28 vdout1_28ck148 = 1.6 time = 1490
* CHECK dout1_29 vdout1_29ck148 = 1.6 time = 1490
* CHECK dout1_30 vdout1_30ck148 = 1.6 time = 1490
* CHECK dout1_31 vdout1_31ck148 = 1.6 time = 1490
* CHECK dout1_32 vdout1_32ck148 = 0 time = 1490
* CHECK dout1_0 vdout1_0ck150 = 1.6 time = 1510
* CHECK dout1_1 vdout1_1ck150 = 1.6 time = 1510
* CHECK dout1_2 vdout1_2ck150 = 1.6 time = 1510
* CHECK dout1_3 vdout1_3ck150 = 0 time = 1510
* CHECK dout1_4 vdout1_4ck150 = 0 time = 1510
* CHECK dout1_5 vdout1_5ck150 = 0 time = 1510
* CHECK dout1_6 vdout1_6ck150 = 0 time = 1510
* CHECK dout1_7 vdout1_7ck150 = 1.6 time = 1510
* CHECK dout1_8 vdout1_8ck150 = 0 time = 1510
* CHECK dout1_9 vdout1_9ck150 = 1.6 time = 1510
* CHECK dout1_10 vdout1_10ck150 = 0 time = 1510
* CHECK dout1_11 vdout1_11ck150 = 0 time = 1510
* CHECK dout1_12 vdout1_12ck150 = 1.6 time = 1510
* CHECK dout1_13 vdout1_13ck150 = 1.6 time = 1510
* CHECK dout1_14 vdout1_14ck150 = 1.6 time = 1510
* CHECK dout1_15 vdout1_15ck150 = 0 time = 1510
* CHECK dout1_16 vdout1_16ck150 = 0 time = 1510
* CHECK dout1_17 vdout1_17ck150 = 1.6 time = 1510
* CHECK dout1_18 vdout1_18ck150 = 1.6 time = 1510
* CHECK dout1_19 vdout1_19ck150 = 1.6 time = 1510
* CHECK dout1_20 vdout1_20ck150 = 1.6 time = 1510
* CHECK dout1_21 vdout1_21ck150 = 0 time = 1510
* CHECK dout1_22 vdout1_22ck150 = 0 time = 1510
* CHECK dout1_23 vdout1_23ck150 = 0 time = 1510
* CHECK dout1_24 vdout1_24ck150 = 1.6 time = 1510
* CHECK dout1_25 vdout1_25ck150 = 1.6 time = 1510
* CHECK dout1_26 vdout1_26ck150 = 0 time = 1510
* CHECK dout1_27 vdout1_27ck150 = 0 time = 1510
* CHECK dout1_28 vdout1_28ck150 = 0 time = 1510
* CHECK dout1_29 vdout1_29ck150 = 0 time = 1510
* CHECK dout1_30 vdout1_30ck150 = 1.6 time = 1510
* CHECK dout1_31 vdout1_31ck150 = 0 time = 1510
* CHECK dout1_32 vdout1_32ck150 = 0 time = 1510
* CHECK dout0_0 vdout0_0ck151 = 0 time = 1520
* CHECK dout0_1 vdout0_1ck151 = 0 time = 1520
* CHECK dout0_2 vdout0_2ck151 = 0 time = 1520
* CHECK dout0_3 vdout0_3ck151 = 1.6 time = 1520
* CHECK dout0_4 vdout0_4ck151 = 0 time = 1520
* CHECK dout0_5 vdout0_5ck151 = 0 time = 1520
* CHECK dout0_6 vdout0_6ck151 = 0 time = 1520
* CHECK dout0_7 vdout0_7ck151 = 0 time = 1520
* CHECK dout0_8 vdout0_8ck151 = 0 time = 1520
* CHECK dout0_9 vdout0_9ck151 = 1.6 time = 1520
* CHECK dout0_10 vdout0_10ck151 = 0 time = 1520
* CHECK dout0_11 vdout0_11ck151 = 0 time = 1520
* CHECK dout0_12 vdout0_12ck151 = 1.6 time = 1520
* CHECK dout0_13 vdout0_13ck151 = 1.6 time = 1520
* CHECK dout0_14 vdout0_14ck151 = 0 time = 1520
* CHECK dout0_15 vdout0_15ck151 = 1.6 time = 1520
* CHECK dout0_16 vdout0_16ck151 = 1.6 time = 1520
* CHECK dout0_17 vdout0_17ck151 = 1.6 time = 1520
* CHECK dout0_18 vdout0_18ck151 = 1.6 time = 1520
* CHECK dout0_19 vdout0_19ck151 = 0 time = 1520
* CHECK dout0_20 vdout0_20ck151 = 0 time = 1520
* CHECK dout0_21 vdout0_21ck151 = 0 time = 1520
* CHECK dout0_22 vdout0_22ck151 = 1.6 time = 1520
* CHECK dout0_23 vdout0_23ck151 = 1.6 time = 1520
* CHECK dout0_24 vdout0_24ck151 = 0 time = 1520
* CHECK dout0_25 vdout0_25ck151 = 1.6 time = 1520
* CHECK dout0_26 vdout0_26ck151 = 0 time = 1520
* CHECK dout0_27 vdout0_27ck151 = 1.6 time = 1520
* CHECK dout0_28 vdout0_28ck151 = 0 time = 1520
* CHECK dout0_29 vdout0_29ck151 = 0 time = 1520
* CHECK dout0_30 vdout0_30ck151 = 1.6 time = 1520
* CHECK dout0_31 vdout0_31ck151 = 1.6 time = 1520
* CHECK dout0_32 vdout0_32ck151 = 0 time = 1520
* CHECK dout1_0 vdout1_0ck151 = 1.6 time = 1520
* CHECK dout1_1 vdout1_1ck151 = 1.6 time = 1520
* CHECK dout1_2 vdout1_2ck151 = 1.6 time = 1520
* CHECK dout1_3 vdout1_3ck151 = 0 time = 1520
* CHECK dout1_4 vdout1_4ck151 = 0 time = 1520
* CHECK dout1_5 vdout1_5ck151 = 0 time = 1520
* CHECK dout1_6 vdout1_6ck151 = 0 time = 1520
* CHECK dout1_7 vdout1_7ck151 = 1.6 time = 1520
* CHECK dout1_8 vdout1_8ck151 = 0 time = 1520
* CHECK dout1_9 vdout1_9ck151 = 1.6 time = 1520
* CHECK dout1_10 vdout1_10ck151 = 0 time = 1520
* CHECK dout1_11 vdout1_11ck151 = 0 time = 1520
* CHECK dout1_12 vdout1_12ck151 = 1.6 time = 1520
* CHECK dout1_13 vdout1_13ck151 = 1.6 time = 1520
* CHECK dout1_14 vdout1_14ck151 = 1.6 time = 1520
* CHECK dout1_15 vdout1_15ck151 = 0 time = 1520
* CHECK dout1_16 vdout1_16ck151 = 0 time = 1520
* CHECK dout1_17 vdout1_17ck151 = 1.6 time = 1520
* CHECK dout1_18 vdout1_18ck151 = 1.6 time = 1520
* CHECK dout1_19 vdout1_19ck151 = 1.6 time = 1520
* CHECK dout1_20 vdout1_20ck151 = 1.6 time = 1520
* CHECK dout1_21 vdout1_21ck151 = 0 time = 1520
* CHECK dout1_22 vdout1_22ck151 = 0 time = 1520
* CHECK dout1_23 vdout1_23ck151 = 0 time = 1520
* CHECK dout1_24 vdout1_24ck151 = 1.6 time = 1520
* CHECK dout1_25 vdout1_25ck151 = 1.6 time = 1520
* CHECK dout1_26 vdout1_26ck151 = 0 time = 1520
* CHECK dout1_27 vdout1_27ck151 = 0 time = 1520
* CHECK dout1_28 vdout1_28ck151 = 0 time = 1520
* CHECK dout1_29 vdout1_29ck151 = 0 time = 1520
* CHECK dout1_30 vdout1_30ck151 = 1.6 time = 1520
* CHECK dout1_31 vdout1_31ck151 = 0 time = 1520
* CHECK dout1_32 vdout1_32ck151 = 0 time = 1520
* CHECK dout0_0 vdout0_0ck152 = 0 time = 1530
* CHECK dout0_1 vdout0_1ck152 = 0 time = 1530
* CHECK dout0_2 vdout0_2ck152 = 0 time = 1530
* CHECK dout0_3 vdout0_3ck152 = 1.6 time = 1530
* CHECK dout0_4 vdout0_4ck152 = 0 time = 1530
* CHECK dout0_5 vdout0_5ck152 = 0 time = 1530
* CHECK dout0_6 vdout0_6ck152 = 0 time = 1530
* CHECK dout0_7 vdout0_7ck152 = 0 time = 1530
* CHECK dout0_8 vdout0_8ck152 = 0 time = 1530
* CHECK dout0_9 vdout0_9ck152 = 1.6 time = 1530
* CHECK dout0_10 vdout0_10ck152 = 0 time = 1530
* CHECK dout0_11 vdout0_11ck152 = 0 time = 1530
* CHECK dout0_12 vdout0_12ck152 = 1.6 time = 1530
* CHECK dout0_13 vdout0_13ck152 = 1.6 time = 1530
* CHECK dout0_14 vdout0_14ck152 = 0 time = 1530
* CHECK dout0_15 vdout0_15ck152 = 1.6 time = 1530
* CHECK dout0_16 vdout0_16ck152 = 1.6 time = 1530
* CHECK dout0_17 vdout0_17ck152 = 1.6 time = 1530
* CHECK dout0_18 vdout0_18ck152 = 1.6 time = 1530
* CHECK dout0_19 vdout0_19ck152 = 0 time = 1530
* CHECK dout0_20 vdout0_20ck152 = 0 time = 1530
* CHECK dout0_21 vdout0_21ck152 = 0 time = 1530
* CHECK dout0_22 vdout0_22ck152 = 1.6 time = 1530
* CHECK dout0_23 vdout0_23ck152 = 1.6 time = 1530
* CHECK dout0_24 vdout0_24ck152 = 0 time = 1530
* CHECK dout0_25 vdout0_25ck152 = 1.6 time = 1530
* CHECK dout0_26 vdout0_26ck152 = 0 time = 1530
* CHECK dout0_27 vdout0_27ck152 = 1.6 time = 1530
* CHECK dout0_28 vdout0_28ck152 = 0 time = 1530
* CHECK dout0_29 vdout0_29ck152 = 0 time = 1530
* CHECK dout0_30 vdout0_30ck152 = 1.6 time = 1530
* CHECK dout0_31 vdout0_31ck152 = 1.6 time = 1530
* CHECK dout0_32 vdout0_32ck152 = 0 time = 1530
* CHECK dout1_0 vdout1_0ck152 = 0 time = 1530
* CHECK dout1_1 vdout1_1ck152 = 0 time = 1530
* CHECK dout1_2 vdout1_2ck152 = 0 time = 1530
* CHECK dout1_3 vdout1_3ck152 = 1.6 time = 1530
* CHECK dout1_4 vdout1_4ck152 = 0 time = 1530
* CHECK dout1_5 vdout1_5ck152 = 0 time = 1530
* CHECK dout1_6 vdout1_6ck152 = 0 time = 1530
* CHECK dout1_7 vdout1_7ck152 = 0 time = 1530
* CHECK dout1_8 vdout1_8ck152 = 0 time = 1530
* CHECK dout1_9 vdout1_9ck152 = 1.6 time = 1530
* CHECK dout1_10 vdout1_10ck152 = 0 time = 1530
* CHECK dout1_11 vdout1_11ck152 = 0 time = 1530
* CHECK dout1_12 vdout1_12ck152 = 1.6 time = 1530
* CHECK dout1_13 vdout1_13ck152 = 1.6 time = 1530
* CHECK dout1_14 vdout1_14ck152 = 0 time = 1530
* CHECK dout1_15 vdout1_15ck152 = 1.6 time = 1530
* CHECK dout1_16 vdout1_16ck152 = 1.6 time = 1530
* CHECK dout1_17 vdout1_17ck152 = 1.6 time = 1530
* CHECK dout1_18 vdout1_18ck152 = 1.6 time = 1530
* CHECK dout1_19 vdout1_19ck152 = 0 time = 1530
* CHECK dout1_20 vdout1_20ck152 = 0 time = 1530
* CHECK dout1_21 vdout1_21ck152 = 0 time = 1530
* CHECK dout1_22 vdout1_22ck152 = 1.6 time = 1530
* CHECK dout1_23 vdout1_23ck152 = 1.6 time = 1530
* CHECK dout1_24 vdout1_24ck152 = 0 time = 1530
* CHECK dout1_25 vdout1_25ck152 = 1.6 time = 1530
* CHECK dout1_26 vdout1_26ck152 = 0 time = 1530
* CHECK dout1_27 vdout1_27ck152 = 1.6 time = 1530
* CHECK dout1_28 vdout1_28ck152 = 0 time = 1530
* CHECK dout1_29 vdout1_29ck152 = 0 time = 1530
* CHECK dout1_30 vdout1_30ck152 = 1.6 time = 1530
* CHECK dout1_31 vdout1_31ck152 = 1.6 time = 1530
* CHECK dout1_32 vdout1_32ck152 = 0 time = 1530
* CHECK dout0_0 vdout0_0ck153 = 1.6 time = 1540
* CHECK dout0_1 vdout0_1ck153 = 0 time = 1540
* CHECK dout0_2 vdout0_2ck153 = 1.6 time = 1540
* CHECK dout0_3 vdout0_3ck153 = 1.6 time = 1540
* CHECK dout0_4 vdout0_4ck153 = 0 time = 1540
* CHECK dout0_5 vdout0_5ck153 = 1.6 time = 1540
* CHECK dout0_6 vdout0_6ck153 = 1.6 time = 1540
* CHECK dout0_7 vdout0_7ck153 = 0 time = 1540
* CHECK dout0_8 vdout0_8ck153 = 0 time = 1540
* CHECK dout0_9 vdout0_9ck153 = 0 time = 1540
* CHECK dout0_10 vdout0_10ck153 = 0 time = 1540
* CHECK dout0_11 vdout0_11ck153 = 0 time = 1540
* CHECK dout0_12 vdout0_12ck153 = 1.6 time = 1540
* CHECK dout0_13 vdout0_13ck153 = 1.6 time = 1540
* CHECK dout0_14 vdout0_14ck153 = 1.6 time = 1540
* CHECK dout0_15 vdout0_15ck153 = 1.6 time = 1540
* CHECK dout0_16 vdout0_16ck153 = 1.6 time = 1540
* CHECK dout0_17 vdout0_17ck153 = 0 time = 1540
* CHECK dout0_18 vdout0_18ck153 = 1.6 time = 1540
* CHECK dout0_19 vdout0_19ck153 = 0 time = 1540
* CHECK dout0_20 vdout0_20ck153 = 0 time = 1540
* CHECK dout0_21 vdout0_21ck153 = 1.6 time = 1540
* CHECK dout0_22 vdout0_22ck153 = 0 time = 1540
* CHECK dout0_23 vdout0_23ck153 = 1.6 time = 1540
* CHECK dout0_24 vdout0_24ck153 = 0 time = 1540
* CHECK dout0_25 vdout0_25ck153 = 1.6 time = 1540
* CHECK dout0_26 vdout0_26ck153 = 0 time = 1540
* CHECK dout0_27 vdout0_27ck153 = 1.6 time = 1540
* CHECK dout0_28 vdout0_28ck153 = 0 time = 1540
* CHECK dout0_29 vdout0_29ck153 = 1.6 time = 1540
* CHECK dout0_30 vdout0_30ck153 = 0 time = 1540
* CHECK dout0_31 vdout0_31ck153 = 0 time = 1540
* CHECK dout0_32 vdout0_32ck153 = 0 time = 1540
* CHECK dout1_0 vdout1_0ck154 = 0 time = 1550
* CHECK dout1_1 vdout1_1ck154 = 0 time = 1550
* CHECK dout1_2 vdout1_2ck154 = 0 time = 1550
* CHECK dout1_3 vdout1_3ck154 = 1.6 time = 1550
* CHECK dout1_4 vdout1_4ck154 = 0 time = 1550
* CHECK dout1_5 vdout1_5ck154 = 0 time = 1550
* CHECK dout1_6 vdout1_6ck154 = 0 time = 1550
* CHECK dout1_7 vdout1_7ck154 = 0 time = 1550
* CHECK dout1_8 vdout1_8ck154 = 0 time = 1550
* CHECK dout1_9 vdout1_9ck154 = 1.6 time = 1550
* CHECK dout1_10 vdout1_10ck154 = 0 time = 1550
* CHECK dout1_11 vdout1_11ck154 = 0 time = 1550
* CHECK dout1_12 vdout1_12ck154 = 1.6 time = 1550
* CHECK dout1_13 vdout1_13ck154 = 1.6 time = 1550
* CHECK dout1_14 vdout1_14ck154 = 0 time = 1550
* CHECK dout1_15 vdout1_15ck154 = 1.6 time = 1550
* CHECK dout1_16 vdout1_16ck154 = 1.6 time = 1550
* CHECK dout1_17 vdout1_17ck154 = 1.6 time = 1550
* CHECK dout1_18 vdout1_18ck154 = 1.6 time = 1550
* CHECK dout1_19 vdout1_19ck154 = 0 time = 1550
* CHECK dout1_20 vdout1_20ck154 = 0 time = 1550
* CHECK dout1_21 vdout1_21ck154 = 0 time = 1550
* CHECK dout1_22 vdout1_22ck154 = 1.6 time = 1550
* CHECK dout1_23 vdout1_23ck154 = 1.6 time = 1550
* CHECK dout1_24 vdout1_24ck154 = 0 time = 1550
* CHECK dout1_25 vdout1_25ck154 = 1.6 time = 1550
* CHECK dout1_26 vdout1_26ck154 = 0 time = 1550
* CHECK dout1_27 vdout1_27ck154 = 1.6 time = 1550
* CHECK dout1_28 vdout1_28ck154 = 0 time = 1550
* CHECK dout1_29 vdout1_29ck154 = 0 time = 1550
* CHECK dout1_30 vdout1_30ck154 = 1.6 time = 1550
* CHECK dout1_31 vdout1_31ck154 = 1.6 time = 1550
* CHECK dout1_32 vdout1_32ck154 = 0 time = 1550
* CHECK dout1_0 vdout1_0ck157 = 1.6 time = 1580
* CHECK dout1_1 vdout1_1ck157 = 1.6 time = 1580
* CHECK dout1_2 vdout1_2ck157 = 0 time = 1580
* CHECK dout1_3 vdout1_3ck157 = 0 time = 1580
* CHECK dout1_4 vdout1_4ck157 = 1.6 time = 1580
* CHECK dout1_5 vdout1_5ck157 = 0 time = 1580
* CHECK dout1_6 vdout1_6ck157 = 0 time = 1580
* CHECK dout1_7 vdout1_7ck157 = 1.6 time = 1580
* CHECK dout1_8 vdout1_8ck157 = 0 time = 1580
* CHECK dout1_9 vdout1_9ck157 = 0 time = 1580
* CHECK dout1_10 vdout1_10ck157 = 1.6 time = 1580
* CHECK dout1_11 vdout1_11ck157 = 1.6 time = 1580
* CHECK dout1_12 vdout1_12ck157 = 1.6 time = 1580
* CHECK dout1_13 vdout1_13ck157 = 1.6 time = 1580
* CHECK dout1_14 vdout1_14ck157 = 0 time = 1580
* CHECK dout1_15 vdout1_15ck157 = 1.6 time = 1580
* CHECK dout1_16 vdout1_16ck157 = 0 time = 1580
* CHECK dout1_17 vdout1_17ck157 = 1.6 time = 1580
* CHECK dout1_18 vdout1_18ck157 = 0 time = 1580
* CHECK dout1_19 vdout1_19ck157 = 1.6 time = 1580
* CHECK dout1_20 vdout1_20ck157 = 0 time = 1580
* CHECK dout1_21 vdout1_21ck157 = 0 time = 1580
* CHECK dout1_22 vdout1_22ck157 = 0 time = 1580
* CHECK dout1_23 vdout1_23ck157 = 0 time = 1580
* CHECK dout1_24 vdout1_24ck157 = 0 time = 1580
* CHECK dout1_25 vdout1_25ck157 = 1.6 time = 1580
* CHECK dout1_26 vdout1_26ck157 = 1.6 time = 1580
* CHECK dout1_27 vdout1_27ck157 = 0 time = 1580
* CHECK dout1_28 vdout1_28ck157 = 1.6 time = 1580
* CHECK dout1_29 vdout1_29ck157 = 0 time = 1580
* CHECK dout1_30 vdout1_30ck157 = 1.6 time = 1580
* CHECK dout1_31 vdout1_31ck157 = 1.6 time = 1580
* CHECK dout1_32 vdout1_32ck157 = 0 time = 1580
* CHECK dout1_0 vdout1_0ck158 = 0 time = 1590
* CHECK dout1_1 vdout1_1ck158 = 0 time = 1590
* CHECK dout1_2 vdout1_2ck158 = 0 time = 1590
* CHECK dout1_3 vdout1_3ck158 = 1.6 time = 1590
* CHECK dout1_4 vdout1_4ck158 = 0 time = 1590
* CHECK dout1_5 vdout1_5ck158 = 0 time = 1590
* CHECK dout1_6 vdout1_6ck158 = 0 time = 1590
* CHECK dout1_7 vdout1_7ck158 = 0 time = 1590
* CHECK dout1_8 vdout1_8ck158 = 0 time = 1590
* CHECK dout1_9 vdout1_9ck158 = 1.6 time = 1590
* CHECK dout1_10 vdout1_10ck158 = 0 time = 1590
* CHECK dout1_11 vdout1_11ck158 = 0 time = 1590
* CHECK dout1_12 vdout1_12ck158 = 1.6 time = 1590
* CHECK dout1_13 vdout1_13ck158 = 1.6 time = 1590
* CHECK dout1_14 vdout1_14ck158 = 0 time = 1590
* CHECK dout1_15 vdout1_15ck158 = 1.6 time = 1590
* CHECK dout1_16 vdout1_16ck158 = 1.6 time = 1590
* CHECK dout1_17 vdout1_17ck158 = 1.6 time = 1590
* CHECK dout1_18 vdout1_18ck158 = 1.6 time = 1590
* CHECK dout1_19 vdout1_19ck158 = 0 time = 1590
* CHECK dout1_20 vdout1_20ck158 = 0 time = 1590
* CHECK dout1_21 vdout1_21ck158 = 0 time = 1590
* CHECK dout1_22 vdout1_22ck158 = 1.6 time = 1590
* CHECK dout1_23 vdout1_23ck158 = 1.6 time = 1590
* CHECK dout1_24 vdout1_24ck158 = 0 time = 1590
* CHECK dout1_25 vdout1_25ck158 = 1.6 time = 1590
* CHECK dout1_26 vdout1_26ck158 = 0 time = 1590
* CHECK dout1_27 vdout1_27ck158 = 1.6 time = 1590
* CHECK dout1_28 vdout1_28ck158 = 0 time = 1590
* CHECK dout1_29 vdout1_29ck158 = 0 time = 1590
* CHECK dout1_30 vdout1_30ck158 = 1.6 time = 1590
* CHECK dout1_31 vdout1_31ck158 = 1.6 time = 1590
* CHECK dout1_32 vdout1_32ck158 = 0 time = 1590
* CHECK dout0_0 vdout0_0ck159 = 1.6 time = 1600
* CHECK dout0_1 vdout0_1ck159 = 0 time = 1600
* CHECK dout0_2 vdout0_2ck159 = 1.6 time = 1600
* CHECK dout0_3 vdout0_3ck159 = 0 time = 1600
* CHECK dout0_4 vdout0_4ck159 = 0 time = 1600
* CHECK dout0_5 vdout0_5ck159 = 1.6 time = 1600
* CHECK dout0_6 vdout0_6ck159 = 0 time = 1600
* CHECK dout0_7 vdout0_7ck159 = 0 time = 1600
* CHECK dout0_8 vdout0_8ck159 = 0 time = 1600
* CHECK dout0_9 vdout0_9ck159 = 1.6 time = 1600
* CHECK dout0_10 vdout0_10ck159 = 0 time = 1600
* CHECK dout0_11 vdout0_11ck159 = 0 time = 1600
* CHECK dout0_12 vdout0_12ck159 = 1.6 time = 1600
* CHECK dout0_13 vdout0_13ck159 = 1.6 time = 1600
* CHECK dout0_14 vdout0_14ck159 = 1.6 time = 1600
* CHECK dout0_15 vdout0_15ck159 = 1.6 time = 1600
* CHECK dout0_16 vdout0_16ck159 = 0 time = 1600
* CHECK dout0_17 vdout0_17ck159 = 0 time = 1600
* CHECK dout0_18 vdout0_18ck159 = 0 time = 1600
* CHECK dout0_19 vdout0_19ck159 = 0 time = 1600
* CHECK dout0_20 vdout0_20ck159 = 0 time = 1600
* CHECK dout0_21 vdout0_21ck159 = 1.6 time = 1600
* CHECK dout0_22 vdout0_22ck159 = 0 time = 1600
* CHECK dout0_23 vdout0_23ck159 = 0 time = 1600
* CHECK dout0_24 vdout0_24ck159 = 1.6 time = 1600
* CHECK dout0_25 vdout0_25ck159 = 0 time = 1600
* CHECK dout0_26 vdout0_26ck159 = 0 time = 1600
* CHECK dout0_27 vdout0_27ck159 = 0 time = 1600
* CHECK dout0_28 vdout0_28ck159 = 0 time = 1600
* CHECK dout0_29 vdout0_29ck159 = 1.6 time = 1600
* CHECK dout0_30 vdout0_30ck159 = 1.6 time = 1600
* CHECK dout0_31 vdout0_31ck159 = 0 time = 1600
* CHECK dout0_32 vdout0_32ck159 = 0 time = 1600
* CHECK dout1_0 vdout1_0ck159 = 1.6 time = 1600
* CHECK dout1_1 vdout1_1ck159 = 1.6 time = 1600
* CHECK dout1_2 vdout1_2ck159 = 0 time = 1600
* CHECK dout1_3 vdout1_3ck159 = 0 time = 1600
* CHECK dout1_4 vdout1_4ck159 = 1.6 time = 1600
* CHECK dout1_5 vdout1_5ck159 = 0 time = 1600
* CHECK dout1_6 vdout1_6ck159 = 0 time = 1600
* CHECK dout1_7 vdout1_7ck159 = 1.6 time = 1600
* CHECK dout1_8 vdout1_8ck159 = 0 time = 1600
* CHECK dout1_9 vdout1_9ck159 = 0 time = 1600
* CHECK dout1_10 vdout1_10ck159 = 1.6 time = 1600
* CHECK dout1_11 vdout1_11ck159 = 1.6 time = 1600
* CHECK dout1_12 vdout1_12ck159 = 1.6 time = 1600
* CHECK dout1_13 vdout1_13ck159 = 1.6 time = 1600
* CHECK dout1_14 vdout1_14ck159 = 0 time = 1600
* CHECK dout1_15 vdout1_15ck159 = 1.6 time = 1600
* CHECK dout1_16 vdout1_16ck159 = 0 time = 1600
* CHECK dout1_17 vdout1_17ck159 = 1.6 time = 1600
* CHECK dout1_18 vdout1_18ck159 = 0 time = 1600
* CHECK dout1_19 vdout1_19ck159 = 1.6 time = 1600
* CHECK dout1_20 vdout1_20ck159 = 0 time = 1600
* CHECK dout1_21 vdout1_21ck159 = 0 time = 1600
* CHECK dout1_22 vdout1_22ck159 = 0 time = 1600
* CHECK dout1_23 vdout1_23ck159 = 0 time = 1600
* CHECK dout1_24 vdout1_24ck159 = 0 time = 1600
* CHECK dout1_25 vdout1_25ck159 = 1.6 time = 1600
* CHECK dout1_26 vdout1_26ck159 = 1.6 time = 1600
* CHECK dout1_27 vdout1_27ck159 = 0 time = 1600
* CHECK dout1_28 vdout1_28ck159 = 1.6 time = 1600
* CHECK dout1_29 vdout1_29ck159 = 0 time = 1600
* CHECK dout1_30 vdout1_30ck159 = 1.6 time = 1600
* CHECK dout1_31 vdout1_31ck159 = 1.6 time = 1600
* CHECK dout1_32 vdout1_32ck159 = 0 time = 1600
* CHECK dout0_0 vdout0_0ck160 = 0 time = 1610
* CHECK dout0_1 vdout0_1ck160 = 1.6 time = 1610
* CHECK dout0_2 vdout0_2ck160 = 1.6 time = 1610
* CHECK dout0_3 vdout0_3ck160 = 0 time = 1610
* CHECK dout0_4 vdout0_4ck160 = 0 time = 1610
* CHECK dout0_5 vdout0_5ck160 = 0 time = 1610
* CHECK dout0_6 vdout0_6ck160 = 0 time = 1610
* CHECK dout0_7 vdout0_7ck160 = 1.6 time = 1610
* CHECK dout0_8 vdout0_8ck160 = 0 time = 1610
* CHECK dout0_9 vdout0_9ck160 = 0 time = 1610
* CHECK dout0_10 vdout0_10ck160 = 0 time = 1610
* CHECK dout0_11 vdout0_11ck160 = 0 time = 1610
* CHECK dout0_12 vdout0_12ck160 = 1.6 time = 1610
* CHECK dout0_13 vdout0_13ck160 = 1.6 time = 1610
* CHECK dout0_14 vdout0_14ck160 = 0 time = 1610
* CHECK dout0_15 vdout0_15ck160 = 0 time = 1610
* CHECK dout0_16 vdout0_16ck160 = 1.6 time = 1610
* CHECK dout0_17 vdout0_17ck160 = 1.6 time = 1610
* CHECK dout0_18 vdout0_18ck160 = 1.6 time = 1610
* CHECK dout0_19 vdout0_19ck160 = 1.6 time = 1610
* CHECK dout0_20 vdout0_20ck160 = 0 time = 1610
* CHECK dout0_21 vdout0_21ck160 = 1.6 time = 1610
* CHECK dout0_22 vdout0_22ck160 = 0 time = 1610
* CHECK dout0_23 vdout0_23ck160 = 1.6 time = 1610
* CHECK dout0_24 vdout0_24ck160 = 1.6 time = 1610
* CHECK dout0_25 vdout0_25ck160 = 0 time = 1610
* CHECK dout0_26 vdout0_26ck160 = 1.6 time = 1610
* CHECK dout0_27 vdout0_27ck160 = 1.6 time = 1610
* CHECK dout0_28 vdout0_28ck160 = 1.6 time = 1610
* CHECK dout0_29 vdout0_29ck160 = 0 time = 1610
* CHECK dout0_30 vdout0_30ck160 = 0 time = 1610
* CHECK dout0_31 vdout0_31ck160 = 1.6 time = 1610
* CHECK dout0_32 vdout0_32ck160 = 0 time = 1610
* CHECK dout1_0 vdout1_0ck160 = 0 time = 1610
* CHECK dout1_1 vdout1_1ck160 = 1.6 time = 1610
* CHECK dout1_2 vdout1_2ck160 = 1.6 time = 1610
* CHECK dout1_3 vdout1_3ck160 = 0 time = 1610
* CHECK dout1_4 vdout1_4ck160 = 0 time = 1610
* CHECK dout1_5 vdout1_5ck160 = 0 time = 1610
* CHECK dout1_6 vdout1_6ck160 = 0 time = 1610
* CHECK dout1_7 vdout1_7ck160 = 1.6 time = 1610
* CHECK dout1_8 vdout1_8ck160 = 0 time = 1610
* CHECK dout1_9 vdout1_9ck160 = 0 time = 1610
* CHECK dout1_10 vdout1_10ck160 = 0 time = 1610
* CHECK dout1_11 vdout1_11ck160 = 0 time = 1610
* CHECK dout1_12 vdout1_12ck160 = 1.6 time = 1610
* CHECK dout1_13 vdout1_13ck160 = 1.6 time = 1610
* CHECK dout1_14 vdout1_14ck160 = 0 time = 1610
* CHECK dout1_15 vdout1_15ck160 = 0 time = 1610
* CHECK dout1_16 vdout1_16ck160 = 1.6 time = 1610
* CHECK dout1_17 vdout1_17ck160 = 1.6 time = 1610
* CHECK dout1_18 vdout1_18ck160 = 1.6 time = 1610
* CHECK dout1_19 vdout1_19ck160 = 1.6 time = 1610
* CHECK dout1_20 vdout1_20ck160 = 0 time = 1610
* CHECK dout1_21 vdout1_21ck160 = 1.6 time = 1610
* CHECK dout1_22 vdout1_22ck160 = 0 time = 1610
* CHECK dout1_23 vdout1_23ck160 = 1.6 time = 1610
* CHECK dout1_24 vdout1_24ck160 = 1.6 time = 1610
* CHECK dout1_25 vdout1_25ck160 = 0 time = 1610
* CHECK dout1_26 vdout1_26ck160 = 1.6 time = 1610
* CHECK dout1_27 vdout1_27ck160 = 1.6 time = 1610
* CHECK dout1_28 vdout1_28ck160 = 1.6 time = 1610
* CHECK dout1_29 vdout1_29ck160 = 0 time = 1610
* CHECK dout1_30 vdout1_30ck160 = 0 time = 1610
* CHECK dout1_31 vdout1_31ck160 = 1.6 time = 1610
* CHECK dout1_32 vdout1_32ck160 = 0 time = 1610
* CHECK dout0_0 vdout0_0ck162 = 1.6 time = 1630
* CHECK dout0_1 vdout0_1ck162 = 0 time = 1630
* CHECK dout0_2 vdout0_2ck162 = 1.6 time = 1630
* CHECK dout0_3 vdout0_3ck162 = 0 time = 1630
* CHECK dout0_4 vdout0_4ck162 = 0 time = 1630
* CHECK dout0_5 vdout0_5ck162 = 1.6 time = 1630
* CHECK dout0_6 vdout0_6ck162 = 0 time = 1630
* CHECK dout0_7 vdout0_7ck162 = 0 time = 1630
* CHECK dout0_8 vdout0_8ck162 = 0 time = 1630
* CHECK dout0_9 vdout0_9ck162 = 1.6 time = 1630
* CHECK dout0_10 vdout0_10ck162 = 0 time = 1630
* CHECK dout0_11 vdout0_11ck162 = 0 time = 1630
* CHECK dout0_12 vdout0_12ck162 = 1.6 time = 1630
* CHECK dout0_13 vdout0_13ck162 = 1.6 time = 1630
* CHECK dout0_14 vdout0_14ck162 = 1.6 time = 1630
* CHECK dout0_15 vdout0_15ck162 = 1.6 time = 1630
* CHECK dout0_16 vdout0_16ck162 = 0 time = 1630
* CHECK dout0_17 vdout0_17ck162 = 0 time = 1630
* CHECK dout0_18 vdout0_18ck162 = 0 time = 1630
* CHECK dout0_19 vdout0_19ck162 = 0 time = 1630
* CHECK dout0_20 vdout0_20ck162 = 0 time = 1630
* CHECK dout0_21 vdout0_21ck162 = 1.6 time = 1630
* CHECK dout0_22 vdout0_22ck162 = 0 time = 1630
* CHECK dout0_23 vdout0_23ck162 = 0 time = 1630
* CHECK dout0_24 vdout0_24ck162 = 1.6 time = 1630
* CHECK dout0_25 vdout0_25ck162 = 0 time = 1630
* CHECK dout0_26 vdout0_26ck162 = 0 time = 1630
* CHECK dout0_27 vdout0_27ck162 = 0 time = 1630
* CHECK dout0_28 vdout0_28ck162 = 0 time = 1630
* CHECK dout0_29 vdout0_29ck162 = 1.6 time = 1630
* CHECK dout0_30 vdout0_30ck162 = 1.6 time = 1630
* CHECK dout0_31 vdout0_31ck162 = 0 time = 1630
* CHECK dout0_32 vdout0_32ck162 = 0 time = 1630
* CHECK dout0_0 vdout0_0ck163 = 1.6 time = 1640
* CHECK dout0_1 vdout0_1ck163 = 0 time = 1640
* CHECK dout0_2 vdout0_2ck163 = 1.6 time = 1640
* CHECK dout0_3 vdout0_3ck163 = 0 time = 1640
* CHECK dout0_4 vdout0_4ck163 = 0 time = 1640
* CHECK dout0_5 vdout0_5ck163 = 1.6 time = 1640
* CHECK dout0_6 vdout0_6ck163 = 0 time = 1640
* CHECK dout0_7 vdout0_7ck163 = 0 time = 1640
* CHECK dout0_8 vdout0_8ck163 = 0 time = 1640
* CHECK dout0_9 vdout0_9ck163 = 1.6 time = 1640
* CHECK dout0_10 vdout0_10ck163 = 0 time = 1640
* CHECK dout0_11 vdout0_11ck163 = 0 time = 1640
* CHECK dout0_12 vdout0_12ck163 = 1.6 time = 1640
* CHECK dout0_13 vdout0_13ck163 = 1.6 time = 1640
* CHECK dout0_14 vdout0_14ck163 = 1.6 time = 1640
* CHECK dout0_15 vdout0_15ck163 = 1.6 time = 1640
* CHECK dout0_16 vdout0_16ck163 = 0 time = 1640
* CHECK dout0_17 vdout0_17ck163 = 0 time = 1640
* CHECK dout0_18 vdout0_18ck163 = 0 time = 1640
* CHECK dout0_19 vdout0_19ck163 = 0 time = 1640
* CHECK dout0_20 vdout0_20ck163 = 0 time = 1640
* CHECK dout0_21 vdout0_21ck163 = 1.6 time = 1640
* CHECK dout0_22 vdout0_22ck163 = 0 time = 1640
* CHECK dout0_23 vdout0_23ck163 = 0 time = 1640
* CHECK dout0_24 vdout0_24ck163 = 1.6 time = 1640
* CHECK dout0_25 vdout0_25ck163 = 0 time = 1640
* CHECK dout0_26 vdout0_26ck163 = 0 time = 1640
* CHECK dout0_27 vdout0_27ck163 = 0 time = 1640
* CHECK dout0_28 vdout0_28ck163 = 0 time = 1640
* CHECK dout0_29 vdout0_29ck163 = 1.6 time = 1640
* CHECK dout0_30 vdout0_30ck163 = 1.6 time = 1640
* CHECK dout0_31 vdout0_31ck163 = 0 time = 1640
* CHECK dout0_32 vdout0_32ck163 = 0 time = 1640
* CHECK dout1_0 vdout1_0ck163 = 0 time = 1640
* CHECK dout1_1 vdout1_1ck163 = 1.6 time = 1640
* CHECK dout1_2 vdout1_2ck163 = 1.6 time = 1640
* CHECK dout1_3 vdout1_3ck163 = 1.6 time = 1640
* CHECK dout1_4 vdout1_4ck163 = 0 time = 1640
* CHECK dout1_5 vdout1_5ck163 = 0 time = 1640
* CHECK dout1_6 vdout1_6ck163 = 0 time = 1640
* CHECK dout1_7 vdout1_7ck163 = 0 time = 1640
* CHECK dout1_8 vdout1_8ck163 = 1.6 time = 1640
* CHECK dout1_9 vdout1_9ck163 = 0 time = 1640
* CHECK dout1_10 vdout1_10ck163 = 0 time = 1640
* CHECK dout1_11 vdout1_11ck163 = 0 time = 1640
* CHECK dout1_12 vdout1_12ck163 = 1.6 time = 1640
* CHECK dout1_13 vdout1_13ck163 = 0 time = 1640
* CHECK dout1_14 vdout1_14ck163 = 1.6 time = 1640
* CHECK dout1_15 vdout1_15ck163 = 0 time = 1640
* CHECK dout1_16 vdout1_16ck163 = 1.6 time = 1640
* CHECK dout1_17 vdout1_17ck163 = 1.6 time = 1640
* CHECK dout1_18 vdout1_18ck163 = 0 time = 1640
* CHECK dout1_19 vdout1_19ck163 = 0 time = 1640
* CHECK dout1_20 vdout1_20ck163 = 1.6 time = 1640
* CHECK dout1_21 vdout1_21ck163 = 1.6 time = 1640
* CHECK dout1_22 vdout1_22ck163 = 0 time = 1640
* CHECK dout1_23 vdout1_23ck163 = 0 time = 1640
* CHECK dout1_24 vdout1_24ck163 = 1.6 time = 1640
* CHECK dout1_25 vdout1_25ck163 = 1.6 time = 1640
* CHECK dout1_26 vdout1_26ck163 = 0 time = 1640
* CHECK dout1_27 vdout1_27ck163 = 0 time = 1640
* CHECK dout1_28 vdout1_28ck163 = 1.6 time = 1640
* CHECK dout1_29 vdout1_29ck163 = 1.6 time = 1640
* CHECK dout1_30 vdout1_30ck163 = 0 time = 1640
* CHECK dout1_31 vdout1_31ck163 = 0 time = 1640
* CHECK dout1_32 vdout1_32ck163 = 0 time = 1640
* CHECK dout0_0 vdout0_0ck164 = 1.6 time = 1650
* CHECK dout0_1 vdout0_1ck164 = 0 time = 1650
* CHECK dout0_2 vdout0_2ck164 = 1.6 time = 1650
* CHECK dout0_3 vdout0_3ck164 = 0 time = 1650
* CHECK dout0_4 vdout0_4ck164 = 0 time = 1650
* CHECK dout0_5 vdout0_5ck164 = 1.6 time = 1650
* CHECK dout0_6 vdout0_6ck164 = 0 time = 1650
* CHECK dout0_7 vdout0_7ck164 = 0 time = 1650
* CHECK dout0_8 vdout0_8ck164 = 0 time = 1650
* CHECK dout0_9 vdout0_9ck164 = 1.6 time = 1650
* CHECK dout0_10 vdout0_10ck164 = 0 time = 1650
* CHECK dout0_11 vdout0_11ck164 = 0 time = 1650
* CHECK dout0_12 vdout0_12ck164 = 1.6 time = 1650
* CHECK dout0_13 vdout0_13ck164 = 1.6 time = 1650
* CHECK dout0_14 vdout0_14ck164 = 1.6 time = 1650
* CHECK dout0_15 vdout0_15ck164 = 1.6 time = 1650
* CHECK dout0_16 vdout0_16ck164 = 0 time = 1650
* CHECK dout0_17 vdout0_17ck164 = 0 time = 1650
* CHECK dout0_18 vdout0_18ck164 = 0 time = 1650
* CHECK dout0_19 vdout0_19ck164 = 0 time = 1650
* CHECK dout0_20 vdout0_20ck164 = 0 time = 1650
* CHECK dout0_21 vdout0_21ck164 = 1.6 time = 1650
* CHECK dout0_22 vdout0_22ck164 = 0 time = 1650
* CHECK dout0_23 vdout0_23ck164 = 0 time = 1650
* CHECK dout0_24 vdout0_24ck164 = 1.6 time = 1650
* CHECK dout0_25 vdout0_25ck164 = 0 time = 1650
* CHECK dout0_26 vdout0_26ck164 = 0 time = 1650
* CHECK dout0_27 vdout0_27ck164 = 0 time = 1650
* CHECK dout0_28 vdout0_28ck164 = 0 time = 1650
* CHECK dout0_29 vdout0_29ck164 = 1.6 time = 1650
* CHECK dout0_30 vdout0_30ck164 = 1.6 time = 1650
* CHECK dout0_31 vdout0_31ck164 = 0 time = 1650
* CHECK dout0_32 vdout0_32ck164 = 0 time = 1650
* CHECK dout0_0 vdout0_0ck165 = 1.6 time = 1660
* CHECK dout0_1 vdout0_1ck165 = 0 time = 1660
* CHECK dout0_2 vdout0_2ck165 = 1.6 time = 1660
* CHECK dout0_3 vdout0_3ck165 = 0 time = 1660
* CHECK dout0_4 vdout0_4ck165 = 0 time = 1660
* CHECK dout0_5 vdout0_5ck165 = 1.6 time = 1660
* CHECK dout0_6 vdout0_6ck165 = 0 time = 1660
* CHECK dout0_7 vdout0_7ck165 = 0 time = 1660
* CHECK dout0_8 vdout0_8ck165 = 0 time = 1660
* CHECK dout0_9 vdout0_9ck165 = 1.6 time = 1660
* CHECK dout0_10 vdout0_10ck165 = 0 time = 1660
* CHECK dout0_11 vdout0_11ck165 = 0 time = 1660
* CHECK dout0_12 vdout0_12ck165 = 1.6 time = 1660
* CHECK dout0_13 vdout0_13ck165 = 1.6 time = 1660
* CHECK dout0_14 vdout0_14ck165 = 1.6 time = 1660
* CHECK dout0_15 vdout0_15ck165 = 1.6 time = 1660
* CHECK dout0_16 vdout0_16ck165 = 0 time = 1660
* CHECK dout0_17 vdout0_17ck165 = 0 time = 1660
* CHECK dout0_18 vdout0_18ck165 = 0 time = 1660
* CHECK dout0_19 vdout0_19ck165 = 0 time = 1660
* CHECK dout0_20 vdout0_20ck165 = 0 time = 1660
* CHECK dout0_21 vdout0_21ck165 = 1.6 time = 1660
* CHECK dout0_22 vdout0_22ck165 = 0 time = 1660
* CHECK dout0_23 vdout0_23ck165 = 0 time = 1660
* CHECK dout0_24 vdout0_24ck165 = 1.6 time = 1660
* CHECK dout0_25 vdout0_25ck165 = 0 time = 1660
* CHECK dout0_26 vdout0_26ck165 = 0 time = 1660
* CHECK dout0_27 vdout0_27ck165 = 0 time = 1660
* CHECK dout0_28 vdout0_28ck165 = 0 time = 1660
* CHECK dout0_29 vdout0_29ck165 = 1.6 time = 1660
* CHECK dout0_30 vdout0_30ck165 = 1.6 time = 1660
* CHECK dout0_31 vdout0_31ck165 = 0 time = 1660
* CHECK dout0_32 vdout0_32ck165 = 0 time = 1660
* CHECK dout0_0 vdout0_0ck168 = 0 time = 1690
* CHECK dout0_1 vdout0_1ck168 = 1.6 time = 1690
* CHECK dout0_2 vdout0_2ck168 = 1.6 time = 1690
* CHECK dout0_3 vdout0_3ck168 = 1.6 time = 1690
* CHECK dout0_4 vdout0_4ck168 = 0 time = 1690
* CHECK dout0_5 vdout0_5ck168 = 0 time = 1690
* CHECK dout0_6 vdout0_6ck168 = 0 time = 1690
* CHECK dout0_7 vdout0_7ck168 = 0 time = 1690
* CHECK dout0_8 vdout0_8ck168 = 1.6 time = 1690
* CHECK dout0_9 vdout0_9ck168 = 0 time = 1690
* CHECK dout0_10 vdout0_10ck168 = 0 time = 1690
* CHECK dout0_11 vdout0_11ck168 = 0 time = 1690
* CHECK dout0_12 vdout0_12ck168 = 1.6 time = 1690
* CHECK dout0_13 vdout0_13ck168 = 0 time = 1690
* CHECK dout0_14 vdout0_14ck168 = 1.6 time = 1690
* CHECK dout0_15 vdout0_15ck168 = 0 time = 1690
* CHECK dout0_16 vdout0_16ck168 = 1.6 time = 1690
* CHECK dout0_17 vdout0_17ck168 = 1.6 time = 1690
* CHECK dout0_18 vdout0_18ck168 = 0 time = 1690
* CHECK dout0_19 vdout0_19ck168 = 0 time = 1690
* CHECK dout0_20 vdout0_20ck168 = 1.6 time = 1690
* CHECK dout0_21 vdout0_21ck168 = 1.6 time = 1690
* CHECK dout0_22 vdout0_22ck168 = 0 time = 1690
* CHECK dout0_23 vdout0_23ck168 = 0 time = 1690
* CHECK dout0_24 vdout0_24ck168 = 1.6 time = 1690
* CHECK dout0_25 vdout0_25ck168 = 1.6 time = 1690
* CHECK dout0_26 vdout0_26ck168 = 0 time = 1690
* CHECK dout0_27 vdout0_27ck168 = 0 time = 1690
* CHECK dout0_28 vdout0_28ck168 = 1.6 time = 1690
* CHECK dout0_29 vdout0_29ck168 = 1.6 time = 1690
* CHECK dout0_30 vdout0_30ck168 = 0 time = 1690
* CHECK dout0_31 vdout0_31ck168 = 0 time = 1690
* CHECK dout0_32 vdout0_32ck168 = 0 time = 1690
* CHECK dout1_0 vdout1_0ck168 = 0 time = 1690
* CHECK dout1_1 vdout1_1ck168 = 1.6 time = 1690
* CHECK dout1_2 vdout1_2ck168 = 1.6 time = 1690
* CHECK dout1_3 vdout1_3ck168 = 0 time = 1690
* CHECK dout1_4 vdout1_4ck168 = 0 time = 1690
* CHECK dout1_5 vdout1_5ck168 = 0 time = 1690
* CHECK dout1_6 vdout1_6ck168 = 0 time = 1690
* CHECK dout1_7 vdout1_7ck168 = 1.6 time = 1690
* CHECK dout1_8 vdout1_8ck168 = 0 time = 1690
* CHECK dout1_9 vdout1_9ck168 = 0 time = 1690
* CHECK dout1_10 vdout1_10ck168 = 0 time = 1690
* CHECK dout1_11 vdout1_11ck168 = 0 time = 1690
* CHECK dout1_12 vdout1_12ck168 = 1.6 time = 1690
* CHECK dout1_13 vdout1_13ck168 = 1.6 time = 1690
* CHECK dout1_14 vdout1_14ck168 = 0 time = 1690
* CHECK dout1_15 vdout1_15ck168 = 0 time = 1690
* CHECK dout1_16 vdout1_16ck168 = 1.6 time = 1690
* CHECK dout1_17 vdout1_17ck168 = 1.6 time = 1690
* CHECK dout1_18 vdout1_18ck168 = 1.6 time = 1690
* CHECK dout1_19 vdout1_19ck168 = 1.6 time = 1690
* CHECK dout1_20 vdout1_20ck168 = 0 time = 1690
* CHECK dout1_21 vdout1_21ck168 = 1.6 time = 1690
* CHECK dout1_22 vdout1_22ck168 = 0 time = 1690
* CHECK dout1_23 vdout1_23ck168 = 1.6 time = 1690
* CHECK dout1_24 vdout1_24ck168 = 1.6 time = 1690
* CHECK dout1_25 vdout1_25ck168 = 0 time = 1690
* CHECK dout1_26 vdout1_26ck168 = 1.6 time = 1690
* CHECK dout1_27 vdout1_27ck168 = 1.6 time = 1690
* CHECK dout1_28 vdout1_28ck168 = 1.6 time = 1690
* CHECK dout1_29 vdout1_29ck168 = 0 time = 1690
* CHECK dout1_30 vdout1_30ck168 = 0 time = 1690
* CHECK dout1_31 vdout1_31ck168 = 1.6 time = 1690
* CHECK dout1_32 vdout1_32ck168 = 0 time = 1690
* CHECK dout0_0 vdout0_0ck169 = 0 time = 1700
* CHECK dout0_1 vdout0_1ck169 = 1.6 time = 1700
* CHECK dout0_2 vdout0_2ck169 = 1.6 time = 1700
* CHECK dout0_3 vdout0_3ck169 = 0 time = 1700
* CHECK dout0_4 vdout0_4ck169 = 0 time = 1700
* CHECK dout0_5 vdout0_5ck169 = 0 time = 1700
* CHECK dout0_6 vdout0_6ck169 = 0 time = 1700
* CHECK dout0_7 vdout0_7ck169 = 1.6 time = 1700
* CHECK dout0_8 vdout0_8ck169 = 0 time = 1700
* CHECK dout0_9 vdout0_9ck169 = 0 time = 1700
* CHECK dout0_10 vdout0_10ck169 = 0 time = 1700
* CHECK dout0_11 vdout0_11ck169 = 0 time = 1700
* CHECK dout0_12 vdout0_12ck169 = 1.6 time = 1700
* CHECK dout0_13 vdout0_13ck169 = 1.6 time = 1700
* CHECK dout0_14 vdout0_14ck169 = 0 time = 1700
* CHECK dout0_15 vdout0_15ck169 = 0 time = 1700
* CHECK dout0_16 vdout0_16ck169 = 1.6 time = 1700
* CHECK dout0_17 vdout0_17ck169 = 1.6 time = 1700
* CHECK dout0_18 vdout0_18ck169 = 1.6 time = 1700
* CHECK dout0_19 vdout0_19ck169 = 1.6 time = 1700
* CHECK dout0_20 vdout0_20ck169 = 0 time = 1700
* CHECK dout0_21 vdout0_21ck169 = 1.6 time = 1700
* CHECK dout0_22 vdout0_22ck169 = 0 time = 1700
* CHECK dout0_23 vdout0_23ck169 = 1.6 time = 1700
* CHECK dout0_24 vdout0_24ck169 = 1.6 time = 1700
* CHECK dout0_25 vdout0_25ck169 = 0 time = 1700
* CHECK dout0_26 vdout0_26ck169 = 1.6 time = 1700
* CHECK dout0_27 vdout0_27ck169 = 1.6 time = 1700
* CHECK dout0_28 vdout0_28ck169 = 1.6 time = 1700
* CHECK dout0_29 vdout0_29ck169 = 0 time = 1700
* CHECK dout0_30 vdout0_30ck169 = 0 time = 1700
* CHECK dout0_31 vdout0_31ck169 = 1.6 time = 1700
* CHECK dout0_32 vdout0_32ck169 = 0 time = 1700
* CHECK dout1_0 vdout1_0ck171 = 0 time = 1720
* CHECK dout1_1 vdout1_1ck171 = 0 time = 1720
* CHECK dout1_2 vdout1_2ck171 = 0 time = 1720
* CHECK dout1_3 vdout1_3ck171 = 1.6 time = 1720
* CHECK dout1_4 vdout1_4ck171 = 0 time = 1720
* CHECK dout1_5 vdout1_5ck171 = 0 time = 1720
* CHECK dout1_6 vdout1_6ck171 = 0 time = 1720
* CHECK dout1_7 vdout1_7ck171 = 0 time = 1720
* CHECK dout1_8 vdout1_8ck171 = 0 time = 1720
* CHECK dout1_9 vdout1_9ck171 = 1.6 time = 1720
* CHECK dout1_10 vdout1_10ck171 = 0 time = 1720
* CHECK dout1_11 vdout1_11ck171 = 0 time = 1720
* CHECK dout1_12 vdout1_12ck171 = 1.6 time = 1720
* CHECK dout1_13 vdout1_13ck171 = 1.6 time = 1720
* CHECK dout1_14 vdout1_14ck171 = 0 time = 1720
* CHECK dout1_15 vdout1_15ck171 = 1.6 time = 1720
* CHECK dout1_16 vdout1_16ck171 = 1.6 time = 1720
* CHECK dout1_17 vdout1_17ck171 = 1.6 time = 1720
* CHECK dout1_18 vdout1_18ck171 = 1.6 time = 1720
* CHECK dout1_19 vdout1_19ck171 = 0 time = 1720
* CHECK dout1_20 vdout1_20ck171 = 0 time = 1720
* CHECK dout1_21 vdout1_21ck171 = 0 time = 1720
* CHECK dout1_22 vdout1_22ck171 = 1.6 time = 1720
* CHECK dout1_23 vdout1_23ck171 = 1.6 time = 1720
* CHECK dout1_24 vdout1_24ck171 = 0 time = 1720
* CHECK dout1_25 vdout1_25ck171 = 1.6 time = 1720
* CHECK dout1_26 vdout1_26ck171 = 0 time = 1720
* CHECK dout1_27 vdout1_27ck171 = 1.6 time = 1720
* CHECK dout1_28 vdout1_28ck171 = 0 time = 1720
* CHECK dout1_29 vdout1_29ck171 = 0 time = 1720
* CHECK dout1_30 vdout1_30ck171 = 1.6 time = 1720
* CHECK dout1_31 vdout1_31ck171 = 1.6 time = 1720
* CHECK dout1_32 vdout1_32ck171 = 0 time = 1720
* CHECK dout0_0 vdout0_0ck172 = 0 time = 1730
* CHECK dout0_1 vdout0_1ck172 = 0 time = 1730
* CHECK dout0_2 vdout0_2ck172 = 0 time = 1730
* CHECK dout0_3 vdout0_3ck172 = 1.6 time = 1730
* CHECK dout0_4 vdout0_4ck172 = 0 time = 1730
* CHECK dout0_5 vdout0_5ck172 = 0 time = 1730
* CHECK dout0_6 vdout0_6ck172 = 0 time = 1730
* CHECK dout0_7 vdout0_7ck172 = 0 time = 1730
* CHECK dout0_8 vdout0_8ck172 = 0 time = 1730
* CHECK dout0_9 vdout0_9ck172 = 1.6 time = 1730
* CHECK dout0_10 vdout0_10ck172 = 0 time = 1730
* CHECK dout0_11 vdout0_11ck172 = 0 time = 1730
* CHECK dout0_12 vdout0_12ck172 = 1.6 time = 1730
* CHECK dout0_13 vdout0_13ck172 = 1.6 time = 1730
* CHECK dout0_14 vdout0_14ck172 = 0 time = 1730
* CHECK dout0_15 vdout0_15ck172 = 1.6 time = 1730
* CHECK dout0_16 vdout0_16ck172 = 1.6 time = 1730
* CHECK dout0_17 vdout0_17ck172 = 1.6 time = 1730
* CHECK dout0_18 vdout0_18ck172 = 1.6 time = 1730
* CHECK dout0_19 vdout0_19ck172 = 0 time = 1730
* CHECK dout0_20 vdout0_20ck172 = 0 time = 1730
* CHECK dout0_21 vdout0_21ck172 = 0 time = 1730
* CHECK dout0_22 vdout0_22ck172 = 1.6 time = 1730
* CHECK dout0_23 vdout0_23ck172 = 1.6 time = 1730
* CHECK dout0_24 vdout0_24ck172 = 0 time = 1730
* CHECK dout0_25 vdout0_25ck172 = 1.6 time = 1730
* CHECK dout0_26 vdout0_26ck172 = 0 time = 1730
* CHECK dout0_27 vdout0_27ck172 = 1.6 time = 1730
* CHECK dout0_28 vdout0_28ck172 = 0 time = 1730
* CHECK dout0_29 vdout0_29ck172 = 0 time = 1730
* CHECK dout0_30 vdout0_30ck172 = 1.6 time = 1730
* CHECK dout0_31 vdout0_31ck172 = 1.6 time = 1730
* CHECK dout0_32 vdout0_32ck172 = 0 time = 1730
* CHECK dout1_0 vdout1_0ck172 = 0 time = 1730
* CHECK dout1_1 vdout1_1ck172 = 1.6 time = 1730
* CHECK dout1_2 vdout1_2ck172 = 1.6 time = 1730
* CHECK dout1_3 vdout1_3ck172 = 1.6 time = 1730
* CHECK dout1_4 vdout1_4ck172 = 0 time = 1730
* CHECK dout1_5 vdout1_5ck172 = 0 time = 1730
* CHECK dout1_6 vdout1_6ck172 = 0 time = 1730
* CHECK dout1_7 vdout1_7ck172 = 0 time = 1730
* CHECK dout1_8 vdout1_8ck172 = 1.6 time = 1730
* CHECK dout1_9 vdout1_9ck172 = 0 time = 1730
* CHECK dout1_10 vdout1_10ck172 = 0 time = 1730
* CHECK dout1_11 vdout1_11ck172 = 0 time = 1730
* CHECK dout1_12 vdout1_12ck172 = 1.6 time = 1730
* CHECK dout1_13 vdout1_13ck172 = 0 time = 1730
* CHECK dout1_14 vdout1_14ck172 = 1.6 time = 1730
* CHECK dout1_15 vdout1_15ck172 = 0 time = 1730
* CHECK dout1_16 vdout1_16ck172 = 1.6 time = 1730
* CHECK dout1_17 vdout1_17ck172 = 1.6 time = 1730
* CHECK dout1_18 vdout1_18ck172 = 0 time = 1730
* CHECK dout1_19 vdout1_19ck172 = 0 time = 1730
* CHECK dout1_20 vdout1_20ck172 = 1.6 time = 1730
* CHECK dout1_21 vdout1_21ck172 = 1.6 time = 1730
* CHECK dout1_22 vdout1_22ck172 = 0 time = 1730
* CHECK dout1_23 vdout1_23ck172 = 0 time = 1730
* CHECK dout1_24 vdout1_24ck172 = 1.6 time = 1730
* CHECK dout1_25 vdout1_25ck172 = 1.6 time = 1730
* CHECK dout1_26 vdout1_26ck172 = 0 time = 1730
* CHECK dout1_27 vdout1_27ck172 = 0 time = 1730
* CHECK dout1_28 vdout1_28ck172 = 1.6 time = 1730
* CHECK dout1_29 vdout1_29ck172 = 1.6 time = 1730
* CHECK dout1_30 vdout1_30ck172 = 0 time = 1730
* CHECK dout1_31 vdout1_31ck172 = 0 time = 1730
* CHECK dout1_32 vdout1_32ck172 = 0 time = 1730
* CHECK dout0_0 vdout0_0ck173 = 0 time = 1740
* CHECK dout0_1 vdout0_1ck173 = 1.6 time = 1740
* CHECK dout0_2 vdout0_2ck173 = 1.6 time = 1740
* CHECK dout0_3 vdout0_3ck173 = 0 time = 1740
* CHECK dout0_4 vdout0_4ck173 = 1.6 time = 1740
* CHECK dout0_5 vdout0_5ck173 = 0 time = 1740
* CHECK dout0_6 vdout0_6ck173 = 1.6 time = 1740
* CHECK dout0_7 vdout0_7ck173 = 0 time = 1740
* CHECK dout0_8 vdout0_8ck173 = 0 time = 1740
* CHECK dout0_9 vdout0_9ck173 = 0 time = 1740
* CHECK dout0_10 vdout0_10ck173 = 0 time = 1740
* CHECK dout0_11 vdout0_11ck173 = 1.6 time = 1740
* CHECK dout0_12 vdout0_12ck173 = 1.6 time = 1740
* CHECK dout0_13 vdout0_13ck173 = 1.6 time = 1740
* CHECK dout0_14 vdout0_14ck173 = 1.6 time = 1740
* CHECK dout0_15 vdout0_15ck173 = 0 time = 1740
* CHECK dout0_16 vdout0_16ck173 = 0 time = 1740
* CHECK dout0_17 vdout0_17ck173 = 0 time = 1740
* CHECK dout0_18 vdout0_18ck173 = 1.6 time = 1740
* CHECK dout0_19 vdout0_19ck173 = 0 time = 1740
* CHECK dout0_20 vdout0_20ck173 = 1.6 time = 1740
* CHECK dout0_21 vdout0_21ck173 = 1.6 time = 1740
* CHECK dout0_22 vdout0_22ck173 = 0 time = 1740
* CHECK dout0_23 vdout0_23ck173 = 1.6 time = 1740
* CHECK dout0_24 vdout0_24ck173 = 1.6 time = 1740
* CHECK dout0_25 vdout0_25ck173 = 0 time = 1740
* CHECK dout0_26 vdout0_26ck173 = 1.6 time = 1740
* CHECK dout0_27 vdout0_27ck173 = 1.6 time = 1740
* CHECK dout0_28 vdout0_28ck173 = 0 time = 1740
* CHECK dout0_29 vdout0_29ck173 = 1.6 time = 1740
* CHECK dout0_30 vdout0_30ck173 = 0 time = 1740
* CHECK dout0_31 vdout0_31ck173 = 0 time = 1740
* CHECK dout0_32 vdout0_32ck173 = 0 time = 1740
* CHECK dout1_0 vdout1_0ck173 = 0 time = 1740
* CHECK dout1_1 vdout1_1ck173 = 0 time = 1740
* CHECK dout1_2 vdout1_2ck173 = 0 time = 1740
* CHECK dout1_3 vdout1_3ck173 = 1.6 time = 1740
* CHECK dout1_4 vdout1_4ck173 = 0 time = 1740
* CHECK dout1_5 vdout1_5ck173 = 0 time = 1740
* CHECK dout1_6 vdout1_6ck173 = 0 time = 1740
* CHECK dout1_7 vdout1_7ck173 = 0 time = 1740
* CHECK dout1_8 vdout1_8ck173 = 0 time = 1740
* CHECK dout1_9 vdout1_9ck173 = 1.6 time = 1740
* CHECK dout1_10 vdout1_10ck173 = 0 time = 1740
* CHECK dout1_11 vdout1_11ck173 = 0 time = 1740
* CHECK dout1_12 vdout1_12ck173 = 1.6 time = 1740
* CHECK dout1_13 vdout1_13ck173 = 1.6 time = 1740
* CHECK dout1_14 vdout1_14ck173 = 0 time = 1740
* CHECK dout1_15 vdout1_15ck173 = 1.6 time = 1740
* CHECK dout1_16 vdout1_16ck173 = 1.6 time = 1740
* CHECK dout1_17 vdout1_17ck173 = 1.6 time = 1740
* CHECK dout1_18 vdout1_18ck173 = 1.6 time = 1740
* CHECK dout1_19 vdout1_19ck173 = 0 time = 1740
* CHECK dout1_20 vdout1_20ck173 = 0 time = 1740
* CHECK dout1_21 vdout1_21ck173 = 0 time = 1740
* CHECK dout1_22 vdout1_22ck173 = 1.6 time = 1740
* CHECK dout1_23 vdout1_23ck173 = 1.6 time = 1740
* CHECK dout1_24 vdout1_24ck173 = 0 time = 1740
* CHECK dout1_25 vdout1_25ck173 = 1.6 time = 1740
* CHECK dout1_26 vdout1_26ck173 = 0 time = 1740
* CHECK dout1_27 vdout1_27ck173 = 1.6 time = 1740
* CHECK dout1_28 vdout1_28ck173 = 0 time = 1740
* CHECK dout1_29 vdout1_29ck173 = 0 time = 1740
* CHECK dout1_30 vdout1_30ck173 = 1.6 time = 1740
* CHECK dout1_31 vdout1_31ck173 = 1.6 time = 1740
* CHECK dout1_32 vdout1_32ck173 = 0 time = 1740
* CHECK dout0_0 vdout0_0ck175 = 1.6 time = 1760
* CHECK dout0_1 vdout0_1ck175 = 0 time = 1760
* CHECK dout0_2 vdout0_2ck175 = 1.6 time = 1760
* CHECK dout0_3 vdout0_3ck175 = 0 time = 1760
* CHECK dout0_4 vdout0_4ck175 = 1.6 time = 1760
* CHECK dout0_5 vdout0_5ck175 = 0 time = 1760
* CHECK dout0_6 vdout0_6ck175 = 0 time = 1760
* CHECK dout0_7 vdout0_7ck175 = 1.6 time = 1760
* CHECK dout0_8 vdout0_8ck175 = 0 time = 1760
* CHECK dout0_9 vdout0_9ck175 = 0 time = 1760
* CHECK dout0_10 vdout0_10ck175 = 1.6 time = 1760
* CHECK dout0_11 vdout0_11ck175 = 0 time = 1760
* CHECK dout0_12 vdout0_12ck175 = 0 time = 1760
* CHECK dout0_13 vdout0_13ck175 = 1.6 time = 1760
* CHECK dout0_14 vdout0_14ck175 = 1.6 time = 1760
* CHECK dout0_15 vdout0_15ck175 = 0 time = 1760
* CHECK dout0_16 vdout0_16ck175 = 0 time = 1760
* CHECK dout0_17 vdout0_17ck175 = 0 time = 1760
* CHECK dout0_18 vdout0_18ck175 = 0 time = 1760
* CHECK dout0_19 vdout0_19ck175 = 0 time = 1760
* CHECK dout0_20 vdout0_20ck175 = 0 time = 1760
* CHECK dout0_21 vdout0_21ck175 = 0 time = 1760
* CHECK dout0_22 vdout0_22ck175 = 1.6 time = 1760
* CHECK dout0_23 vdout0_23ck175 = 0 time = 1760
* CHECK dout0_24 vdout0_24ck175 = 0 time = 1760
* CHECK dout0_25 vdout0_25ck175 = 1.6 time = 1760
* CHECK dout0_26 vdout0_26ck175 = 0 time = 1760
* CHECK dout0_27 vdout0_27ck175 = 1.6 time = 1760
* CHECK dout0_28 vdout0_28ck175 = 0 time = 1760
* CHECK dout0_29 vdout0_29ck175 = 0 time = 1760
* CHECK dout0_30 vdout0_30ck175 = 1.6 time = 1760
* CHECK dout0_31 vdout0_31ck175 = 1.6 time = 1760
* CHECK dout0_32 vdout0_32ck175 = 0 time = 1760
* CHECK dout0_0 vdout0_0ck176 = 0 time = 1770
* CHECK dout0_1 vdout0_1ck176 = 0 time = 1770
* CHECK dout0_2 vdout0_2ck176 = 0 time = 1770
* CHECK dout0_3 vdout0_3ck176 = 1.6 time = 1770
* CHECK dout0_4 vdout0_4ck176 = 0 time = 1770
* CHECK dout0_5 vdout0_5ck176 = 0 time = 1770
* CHECK dout0_6 vdout0_6ck176 = 0 time = 1770
* CHECK dout0_7 vdout0_7ck176 = 0 time = 1770
* CHECK dout0_8 vdout0_8ck176 = 0 time = 1770
* CHECK dout0_9 vdout0_9ck176 = 1.6 time = 1770
* CHECK dout0_10 vdout0_10ck176 = 0 time = 1770
* CHECK dout0_11 vdout0_11ck176 = 0 time = 1770
* CHECK dout0_12 vdout0_12ck176 = 1.6 time = 1770
* CHECK dout0_13 vdout0_13ck176 = 1.6 time = 1770
* CHECK dout0_14 vdout0_14ck176 = 0 time = 1770
* CHECK dout0_15 vdout0_15ck176 = 1.6 time = 1770
* CHECK dout0_16 vdout0_16ck176 = 1.6 time = 1770
* CHECK dout0_17 vdout0_17ck176 = 1.6 time = 1770
* CHECK dout0_18 vdout0_18ck176 = 1.6 time = 1770
* CHECK dout0_19 vdout0_19ck176 = 0 time = 1770
* CHECK dout0_20 vdout0_20ck176 = 0 time = 1770
* CHECK dout0_21 vdout0_21ck176 = 0 time = 1770
* CHECK dout0_22 vdout0_22ck176 = 1.6 time = 1770
* CHECK dout0_23 vdout0_23ck176 = 1.6 time = 1770
* CHECK dout0_24 vdout0_24ck176 = 0 time = 1770
* CHECK dout0_25 vdout0_25ck176 = 1.6 time = 1770
* CHECK dout0_26 vdout0_26ck176 = 0 time = 1770
* CHECK dout0_27 vdout0_27ck176 = 1.6 time = 1770
* CHECK dout0_28 vdout0_28ck176 = 0 time = 1770
* CHECK dout0_29 vdout0_29ck176 = 0 time = 1770
* CHECK dout0_30 vdout0_30ck176 = 1.6 time = 1770
* CHECK dout0_31 vdout0_31ck176 = 1.6 time = 1770
* CHECK dout0_32 vdout0_32ck176 = 0 time = 1770
* CHECK dout1_0 vdout1_0ck176 = 0 time = 1770
* CHECK dout1_1 vdout1_1ck176 = 1.6 time = 1770
* CHECK dout1_2 vdout1_2ck176 = 1.6 time = 1770
* CHECK dout1_3 vdout1_3ck176 = 0 time = 1770
* CHECK dout1_4 vdout1_4ck176 = 1.6 time = 1770
* CHECK dout1_5 vdout1_5ck176 = 0 time = 1770
* CHECK dout1_6 vdout1_6ck176 = 1.6 time = 1770
* CHECK dout1_7 vdout1_7ck176 = 0 time = 1770
* CHECK dout1_8 vdout1_8ck176 = 0 time = 1770
* CHECK dout1_9 vdout1_9ck176 = 0 time = 1770
* CHECK dout1_10 vdout1_10ck176 = 0 time = 1770
* CHECK dout1_11 vdout1_11ck176 = 1.6 time = 1770
* CHECK dout1_12 vdout1_12ck176 = 1.6 time = 1770
* CHECK dout1_13 vdout1_13ck176 = 1.6 time = 1770
* CHECK dout1_14 vdout1_14ck176 = 1.6 time = 1770
* CHECK dout1_15 vdout1_15ck176 = 0 time = 1770
* CHECK dout1_16 vdout1_16ck176 = 0 time = 1770
* CHECK dout1_17 vdout1_17ck176 = 0 time = 1770
* CHECK dout1_18 vdout1_18ck176 = 1.6 time = 1770
* CHECK dout1_19 vdout1_19ck176 = 0 time = 1770
* CHECK dout1_20 vdout1_20ck176 = 1.6 time = 1770
* CHECK dout1_21 vdout1_21ck176 = 1.6 time = 1770
* CHECK dout1_22 vdout1_22ck176 = 0 time = 1770
* CHECK dout1_23 vdout1_23ck176 = 1.6 time = 1770
* CHECK dout1_24 vdout1_24ck176 = 1.6 time = 1770
* CHECK dout1_25 vdout1_25ck176 = 0 time = 1770
* CHECK dout1_26 vdout1_26ck176 = 1.6 time = 1770
* CHECK dout1_27 vdout1_27ck176 = 1.6 time = 1770
* CHECK dout1_28 vdout1_28ck176 = 0 time = 1770
* CHECK dout1_29 vdout1_29ck176 = 1.6 time = 1770
* CHECK dout1_30 vdout1_30ck176 = 0 time = 1770
* CHECK dout1_31 vdout1_31ck176 = 0 time = 1770
* CHECK dout1_32 vdout1_32ck176 = 0 time = 1770
* CHECK dout0_0 vdout0_0ck177 = 1.6 time = 1780
* CHECK dout0_1 vdout0_1ck177 = 0 time = 1780
* CHECK dout0_2 vdout0_2ck177 = 1.6 time = 1780
* CHECK dout0_3 vdout0_3ck177 = 0 time = 1780
* CHECK dout0_4 vdout0_4ck177 = 1.6 time = 1780
* CHECK dout0_5 vdout0_5ck177 = 0 time = 1780
* CHECK dout0_6 vdout0_6ck177 = 0 time = 1780
* CHECK dout0_7 vdout0_7ck177 = 1.6 time = 1780
* CHECK dout0_8 vdout0_8ck177 = 0 time = 1780
* CHECK dout0_9 vdout0_9ck177 = 0 time = 1780
* CHECK dout0_10 vdout0_10ck177 = 1.6 time = 1780
* CHECK dout0_11 vdout0_11ck177 = 0 time = 1780
* CHECK dout0_12 vdout0_12ck177 = 0 time = 1780
* CHECK dout0_13 vdout0_13ck177 = 1.6 time = 1780
* CHECK dout0_14 vdout0_14ck177 = 1.6 time = 1780
* CHECK dout0_15 vdout0_15ck177 = 0 time = 1780
* CHECK dout0_16 vdout0_16ck177 = 0 time = 1780
* CHECK dout0_17 vdout0_17ck177 = 0 time = 1780
* CHECK dout0_18 vdout0_18ck177 = 0 time = 1780
* CHECK dout0_19 vdout0_19ck177 = 0 time = 1780
* CHECK dout0_20 vdout0_20ck177 = 0 time = 1780
* CHECK dout0_21 vdout0_21ck177 = 0 time = 1780
* CHECK dout0_22 vdout0_22ck177 = 1.6 time = 1780
* CHECK dout0_23 vdout0_23ck177 = 0 time = 1780
* CHECK dout0_24 vdout0_24ck177 = 0 time = 1780
* CHECK dout0_25 vdout0_25ck177 = 1.6 time = 1780
* CHECK dout0_26 vdout0_26ck177 = 0 time = 1780
* CHECK dout0_27 vdout0_27ck177 = 1.6 time = 1780
* CHECK dout0_28 vdout0_28ck177 = 0 time = 1780
* CHECK dout0_29 vdout0_29ck177 = 0 time = 1780
* CHECK dout0_30 vdout0_30ck177 = 1.6 time = 1780
* CHECK dout0_31 vdout0_31ck177 = 1.6 time = 1780
* CHECK dout0_32 vdout0_32ck177 = 0 time = 1780
* CHECK dout1_0 vdout1_0ck178 = 0 time = 1790
* CHECK dout1_1 vdout1_1ck178 = 1.6 time = 1790
* CHECK dout1_2 vdout1_2ck178 = 1.6 time = 1790
* CHECK dout1_3 vdout1_3ck178 = 1.6 time = 1790
* CHECK dout1_4 vdout1_4ck178 = 0 time = 1790
* CHECK dout1_5 vdout1_5ck178 = 0 time = 1790
* CHECK dout1_6 vdout1_6ck178 = 0 time = 1790
* CHECK dout1_7 vdout1_7ck178 = 0 time = 1790
* CHECK dout1_8 vdout1_8ck178 = 1.6 time = 1790
* CHECK dout1_9 vdout1_9ck178 = 0 time = 1790
* CHECK dout1_10 vdout1_10ck178 = 0 time = 1790
* CHECK dout1_11 vdout1_11ck178 = 0 time = 1790
* CHECK dout1_12 vdout1_12ck178 = 1.6 time = 1790
* CHECK dout1_13 vdout1_13ck178 = 0 time = 1790
* CHECK dout1_14 vdout1_14ck178 = 1.6 time = 1790
* CHECK dout1_15 vdout1_15ck178 = 0 time = 1790
* CHECK dout1_16 vdout1_16ck178 = 1.6 time = 1790
* CHECK dout1_17 vdout1_17ck178 = 1.6 time = 1790
* CHECK dout1_18 vdout1_18ck178 = 0 time = 1790
* CHECK dout1_19 vdout1_19ck178 = 0 time = 1790
* CHECK dout1_20 vdout1_20ck178 = 1.6 time = 1790
* CHECK dout1_21 vdout1_21ck178 = 1.6 time = 1790
* CHECK dout1_22 vdout1_22ck178 = 0 time = 1790
* CHECK dout1_23 vdout1_23ck178 = 0 time = 1790
* CHECK dout1_24 vdout1_24ck178 = 1.6 time = 1790
* CHECK dout1_25 vdout1_25ck178 = 1.6 time = 1790
* CHECK dout1_26 vdout1_26ck178 = 0 time = 1790
* CHECK dout1_27 vdout1_27ck178 = 0 time = 1790
* CHECK dout1_28 vdout1_28ck178 = 1.6 time = 1790
* CHECK dout1_29 vdout1_29ck178 = 1.6 time = 1790
* CHECK dout1_30 vdout1_30ck178 = 0 time = 1790
* CHECK dout1_31 vdout1_31ck178 = 0 time = 1790
* CHECK dout1_32 vdout1_32ck178 = 0 time = 1790
* CHECK dout1_0 vdout1_0ck180 = 0 time = 1810
* CHECK dout1_1 vdout1_1ck180 = 0 time = 1810
* CHECK dout1_2 vdout1_2ck180 = 0 time = 1810
* CHECK dout1_3 vdout1_3ck180 = 1.6 time = 1810
* CHECK dout1_4 vdout1_4ck180 = 0 time = 1810
* CHECK dout1_5 vdout1_5ck180 = 0 time = 1810
* CHECK dout1_6 vdout1_6ck180 = 0 time = 1810
* CHECK dout1_7 vdout1_7ck180 = 0 time = 1810
* CHECK dout1_8 vdout1_8ck180 = 0 time = 1810
* CHECK dout1_9 vdout1_9ck180 = 1.6 time = 1810
* CHECK dout1_10 vdout1_10ck180 = 0 time = 1810
* CHECK dout1_11 vdout1_11ck180 = 0 time = 1810
* CHECK dout1_12 vdout1_12ck180 = 1.6 time = 1810
* CHECK dout1_13 vdout1_13ck180 = 1.6 time = 1810
* CHECK dout1_14 vdout1_14ck180 = 0 time = 1810
* CHECK dout1_15 vdout1_15ck180 = 1.6 time = 1810
* CHECK dout1_16 vdout1_16ck180 = 1.6 time = 1810
* CHECK dout1_17 vdout1_17ck180 = 1.6 time = 1810
* CHECK dout1_18 vdout1_18ck180 = 1.6 time = 1810
* CHECK dout1_19 vdout1_19ck180 = 0 time = 1810
* CHECK dout1_20 vdout1_20ck180 = 0 time = 1810
* CHECK dout1_21 vdout1_21ck180 = 0 time = 1810
* CHECK dout1_22 vdout1_22ck180 = 1.6 time = 1810
* CHECK dout1_23 vdout1_23ck180 = 1.6 time = 1810
* CHECK dout1_24 vdout1_24ck180 = 0 time = 1810
* CHECK dout1_25 vdout1_25ck180 = 1.6 time = 1810
* CHECK dout1_26 vdout1_26ck180 = 0 time = 1810
* CHECK dout1_27 vdout1_27ck180 = 1.6 time = 1810
* CHECK dout1_28 vdout1_28ck180 = 0 time = 1810
* CHECK dout1_29 vdout1_29ck180 = 0 time = 1810
* CHECK dout1_30 vdout1_30ck180 = 1.6 time = 1810
* CHECK dout1_31 vdout1_31ck180 = 1.6 time = 1810
* CHECK dout1_32 vdout1_32ck180 = 0 time = 1810
* CHECK dout0_0 vdout0_0ck181 = 1.6 time = 1820
* CHECK dout0_1 vdout0_1ck181 = 0 time = 1820
* CHECK dout0_2 vdout0_2ck181 = 0 time = 1820
* CHECK dout0_3 vdout0_3ck181 = 1.6 time = 1820
* CHECK dout0_4 vdout0_4ck181 = 0 time = 1820
* CHECK dout0_5 vdout0_5ck181 = 0 time = 1820
* CHECK dout0_6 vdout0_6ck181 = 0 time = 1820
* CHECK dout0_7 vdout0_7ck181 = 0 time = 1820
* CHECK dout0_8 vdout0_8ck181 = 1.6 time = 1820
* CHECK dout0_9 vdout0_9ck181 = 0 time = 1820
* CHECK dout0_10 vdout0_10ck181 = 1.6 time = 1820
* CHECK dout0_11 vdout0_11ck181 = 0 time = 1820
* CHECK dout0_12 vdout0_12ck181 = 1.6 time = 1820
* CHECK dout0_13 vdout0_13ck181 = 1.6 time = 1820
* CHECK dout0_14 vdout0_14ck181 = 0 time = 1820
* CHECK dout0_15 vdout0_15ck181 = 0 time = 1820
* CHECK dout0_16 vdout0_16ck181 = 1.6 time = 1820
* CHECK dout0_17 vdout0_17ck181 = 0 time = 1820
* CHECK dout0_18 vdout0_18ck181 = 0 time = 1820
* CHECK dout0_19 vdout0_19ck181 = 0 time = 1820
* CHECK dout0_20 vdout0_20ck181 = 0 time = 1820
* CHECK dout0_21 vdout0_21ck181 = 0 time = 1820
* CHECK dout0_22 vdout0_22ck181 = 0 time = 1820
* CHECK dout0_23 vdout0_23ck181 = 1.6 time = 1820
* CHECK dout0_24 vdout0_24ck181 = 0 time = 1820
* CHECK dout0_25 vdout0_25ck181 = 0 time = 1820
* CHECK dout0_26 vdout0_26ck181 = 0 time = 1820
* CHECK dout0_27 vdout0_27ck181 = 1.6 time = 1820
* CHECK dout0_28 vdout0_28ck181 = 0 time = 1820
* CHECK dout0_29 vdout0_29ck181 = 1.6 time = 1820
* CHECK dout0_30 vdout0_30ck181 = 0 time = 1820
* CHECK dout0_31 vdout0_31ck181 = 0 time = 1820
* CHECK dout0_32 vdout0_32ck181 = 0 time = 1820
* CHECK dout1_0 vdout1_0ck181 = 0 time = 1820
* CHECK dout1_1 vdout1_1ck181 = 0 time = 1820
* CHECK dout1_2 vdout1_2ck181 = 0 time = 1820
* CHECK dout1_3 vdout1_3ck181 = 1.6 time = 1820
* CHECK dout1_4 vdout1_4ck181 = 0 time = 1820
* CHECK dout1_5 vdout1_5ck181 = 0 time = 1820
* CHECK dout1_6 vdout1_6ck181 = 0 time = 1820
* CHECK dout1_7 vdout1_7ck181 = 0 time = 1820
* CHECK dout1_8 vdout1_8ck181 = 0 time = 1820
* CHECK dout1_9 vdout1_9ck181 = 1.6 time = 1820
* CHECK dout1_10 vdout1_10ck181 = 0 time = 1820
* CHECK dout1_11 vdout1_11ck181 = 0 time = 1820
* CHECK dout1_12 vdout1_12ck181 = 1.6 time = 1820
* CHECK dout1_13 vdout1_13ck181 = 1.6 time = 1820
* CHECK dout1_14 vdout1_14ck181 = 0 time = 1820
* CHECK dout1_15 vdout1_15ck181 = 1.6 time = 1820
* CHECK dout1_16 vdout1_16ck181 = 1.6 time = 1820
* CHECK dout1_17 vdout1_17ck181 = 1.6 time = 1820
* CHECK dout1_18 vdout1_18ck181 = 1.6 time = 1820
* CHECK dout1_19 vdout1_19ck181 = 0 time = 1820
* CHECK dout1_20 vdout1_20ck181 = 0 time = 1820
* CHECK dout1_21 vdout1_21ck181 = 0 time = 1820
* CHECK dout1_22 vdout1_22ck181 = 1.6 time = 1820
* CHECK dout1_23 vdout1_23ck181 = 1.6 time = 1820
* CHECK dout1_24 vdout1_24ck181 = 0 time = 1820
* CHECK dout1_25 vdout1_25ck181 = 1.6 time = 1820
* CHECK dout1_26 vdout1_26ck181 = 0 time = 1820
* CHECK dout1_27 vdout1_27ck181 = 1.6 time = 1820
* CHECK dout1_28 vdout1_28ck181 = 0 time = 1820
* CHECK dout1_29 vdout1_29ck181 = 0 time = 1820
* CHECK dout1_30 vdout1_30ck181 = 1.6 time = 1820
* CHECK dout1_31 vdout1_31ck181 = 1.6 time = 1820
* CHECK dout1_32 vdout1_32ck181 = 0 time = 1820
* CHECK dout0_0 vdout0_0ck182 = 1.6 time = 1830
* CHECK dout0_1 vdout0_1ck182 = 1.6 time = 1830
* CHECK dout0_2 vdout0_2ck182 = 0 time = 1830
* CHECK dout0_3 vdout0_3ck182 = 1.6 time = 1830
* CHECK dout0_4 vdout0_4ck182 = 0 time = 1830
* CHECK dout0_5 vdout0_5ck182 = 0 time = 1830
* CHECK dout0_6 vdout0_6ck182 = 0 time = 1830
* CHECK dout0_7 vdout0_7ck182 = 1.6 time = 1830
* CHECK dout0_8 vdout0_8ck182 = 0 time = 1830
* CHECK dout0_9 vdout0_9ck182 = 0 time = 1830
* CHECK dout0_10 vdout0_10ck182 = 1.6 time = 1830
* CHECK dout0_11 vdout0_11ck182 = 0 time = 1830
* CHECK dout0_12 vdout0_12ck182 = 1.6 time = 1830
* CHECK dout0_13 vdout0_13ck182 = 1.6 time = 1830
* CHECK dout0_14 vdout0_14ck182 = 0 time = 1830
* CHECK dout0_15 vdout0_15ck182 = 0 time = 1830
* CHECK dout0_16 vdout0_16ck182 = 0 time = 1830
* CHECK dout0_17 vdout0_17ck182 = 0 time = 1830
* CHECK dout0_18 vdout0_18ck182 = 1.6 time = 1830
* CHECK dout0_19 vdout0_19ck182 = 1.6 time = 1830
* CHECK dout0_20 vdout0_20ck182 = 1.6 time = 1830
* CHECK dout0_21 vdout0_21ck182 = 1.6 time = 1830
* CHECK dout0_22 vdout0_22ck182 = 1.6 time = 1830
* CHECK dout0_23 vdout0_23ck182 = 1.6 time = 1830
* CHECK dout0_24 vdout0_24ck182 = 0 time = 1830
* CHECK dout0_25 vdout0_25ck182 = 1.6 time = 1830
* CHECK dout0_26 vdout0_26ck182 = 1.6 time = 1830
* CHECK dout0_27 vdout0_27ck182 = 0 time = 1830
* CHECK dout0_28 vdout0_28ck182 = 0 time = 1830
* CHECK dout0_29 vdout0_29ck182 = 0 time = 1830
* CHECK dout0_30 vdout0_30ck182 = 1.6 time = 1830
* CHECK dout0_31 vdout0_31ck182 = 1.6 time = 1830
* CHECK dout0_32 vdout0_32ck182 = 0 time = 1830
* CHECK dout0_0 vdout0_0ck184 = 1.6 time = 1850
* CHECK dout0_1 vdout0_1ck184 = 1.6 time = 1850
* CHECK dout0_2 vdout0_2ck184 = 0 time = 1850
* CHECK dout0_3 vdout0_3ck184 = 1.6 time = 1850
* CHECK dout0_4 vdout0_4ck184 = 0 time = 1850
* CHECK dout0_5 vdout0_5ck184 = 0 time = 1850
* CHECK dout0_6 vdout0_6ck184 = 0 time = 1850
* CHECK dout0_7 vdout0_7ck184 = 1.6 time = 1850
* CHECK dout0_8 vdout0_8ck184 = 0 time = 1850
* CHECK dout0_9 vdout0_9ck184 = 0 time = 1850
* CHECK dout0_10 vdout0_10ck184 = 1.6 time = 1850
* CHECK dout0_11 vdout0_11ck184 = 0 time = 1850
* CHECK dout0_12 vdout0_12ck184 = 1.6 time = 1850
* CHECK dout0_13 vdout0_13ck184 = 1.6 time = 1850
* CHECK dout0_14 vdout0_14ck184 = 0 time = 1850
* CHECK dout0_15 vdout0_15ck184 = 0 time = 1850
* CHECK dout0_16 vdout0_16ck184 = 0 time = 1850
* CHECK dout0_17 vdout0_17ck184 = 0 time = 1850
* CHECK dout0_18 vdout0_18ck184 = 1.6 time = 1850
* CHECK dout0_19 vdout0_19ck184 = 1.6 time = 1850
* CHECK dout0_20 vdout0_20ck184 = 1.6 time = 1850
* CHECK dout0_21 vdout0_21ck184 = 1.6 time = 1850
* CHECK dout0_22 vdout0_22ck184 = 1.6 time = 1850
* CHECK dout0_23 vdout0_23ck184 = 1.6 time = 1850
* CHECK dout0_24 vdout0_24ck184 = 0 time = 1850
* CHECK dout0_25 vdout0_25ck184 = 1.6 time = 1850
* CHECK dout0_26 vdout0_26ck184 = 1.6 time = 1850
* CHECK dout0_27 vdout0_27ck184 = 0 time = 1850
* CHECK dout0_28 vdout0_28ck184 = 0 time = 1850
* CHECK dout0_29 vdout0_29ck184 = 0 time = 1850
* CHECK dout0_30 vdout0_30ck184 = 1.6 time = 1850
* CHECK dout0_31 vdout0_31ck184 = 1.6 time = 1850
* CHECK dout0_32 vdout0_32ck184 = 0 time = 1850
* CHECK dout1_0 vdout1_0ck184 = 1.6 time = 1850
* CHECK dout1_1 vdout1_1ck184 = 0 time = 1850
* CHECK dout1_2 vdout1_2ck184 = 0 time = 1850
* CHECK dout1_3 vdout1_3ck184 = 1.6 time = 1850
* CHECK dout1_4 vdout1_4ck184 = 0 time = 1850
* CHECK dout1_5 vdout1_5ck184 = 0 time = 1850
* CHECK dout1_6 vdout1_6ck184 = 0 time = 1850
* CHECK dout1_7 vdout1_7ck184 = 0 time = 1850
* CHECK dout1_8 vdout1_8ck184 = 1.6 time = 1850
* CHECK dout1_9 vdout1_9ck184 = 0 time = 1850
* CHECK dout1_10 vdout1_10ck184 = 1.6 time = 1850
* CHECK dout1_11 vdout1_11ck184 = 0 time = 1850
* CHECK dout1_12 vdout1_12ck184 = 1.6 time = 1850
* CHECK dout1_13 vdout1_13ck184 = 1.6 time = 1850
* CHECK dout1_14 vdout1_14ck184 = 0 time = 1850
* CHECK dout1_15 vdout1_15ck184 = 0 time = 1850
* CHECK dout1_16 vdout1_16ck184 = 1.6 time = 1850
* CHECK dout1_17 vdout1_17ck184 = 0 time = 1850
* CHECK dout1_18 vdout1_18ck184 = 0 time = 1850
* CHECK dout1_19 vdout1_19ck184 = 0 time = 1850
* CHECK dout1_20 vdout1_20ck184 = 0 time = 1850
* CHECK dout1_21 vdout1_21ck184 = 0 time = 1850
* CHECK dout1_22 vdout1_22ck184 = 0 time = 1850
* CHECK dout1_23 vdout1_23ck184 = 1.6 time = 1850
* CHECK dout1_24 vdout1_24ck184 = 0 time = 1850
* CHECK dout1_25 vdout1_25ck184 = 0 time = 1850
* CHECK dout1_26 vdout1_26ck184 = 0 time = 1850
* CHECK dout1_27 vdout1_27ck184 = 1.6 time = 1850
* CHECK dout1_28 vdout1_28ck184 = 0 time = 1850
* CHECK dout1_29 vdout1_29ck184 = 1.6 time = 1850
* CHECK dout1_30 vdout1_30ck184 = 0 time = 1850
* CHECK dout1_31 vdout1_31ck184 = 0 time = 1850
* CHECK dout1_32 vdout1_32ck184 = 0 time = 1850
* CHECK dout0_0 vdout0_0ck185 = 0 time = 1860
* CHECK dout0_1 vdout0_1ck185 = 0 time = 1860
* CHECK dout0_2 vdout0_2ck185 = 0 time = 1860
* CHECK dout0_3 vdout0_3ck185 = 1.6 time = 1860
* CHECK dout0_4 vdout0_4ck185 = 0 time = 1860
* CHECK dout0_5 vdout0_5ck185 = 1.6 time = 1860
* CHECK dout0_6 vdout0_6ck185 = 1.6 time = 1860
* CHECK dout0_7 vdout0_7ck185 = 1.6 time = 1860
* CHECK dout0_8 vdout0_8ck185 = 1.6 time = 1860
* CHECK dout0_9 vdout0_9ck185 = 0 time = 1860
* CHECK dout0_10 vdout0_10ck185 = 0 time = 1860
* CHECK dout0_11 vdout0_11ck185 = 1.6 time = 1860
* CHECK dout0_12 vdout0_12ck185 = 0 time = 1860
* CHECK dout0_13 vdout0_13ck185 = 0 time = 1860
* CHECK dout0_14 vdout0_14ck185 = 1.6 time = 1860
* CHECK dout0_15 vdout0_15ck185 = 1.6 time = 1860
* CHECK dout0_16 vdout0_16ck185 = 1.6 time = 1860
* CHECK dout0_17 vdout0_17ck185 = 1.6 time = 1860
* CHECK dout0_18 vdout0_18ck185 = 1.6 time = 1860
* CHECK dout0_19 vdout0_19ck185 = 0 time = 1860
* CHECK dout0_20 vdout0_20ck185 = 0 time = 1860
* CHECK dout0_21 vdout0_21ck185 = 1.6 time = 1860
* CHECK dout0_22 vdout0_22ck185 = 0 time = 1860
* CHECK dout0_23 vdout0_23ck185 = 0 time = 1860
* CHECK dout0_24 vdout0_24ck185 = 1.6 time = 1860
* CHECK dout0_25 vdout0_25ck185 = 0 time = 1860
* CHECK dout0_26 vdout0_26ck185 = 0 time = 1860
* CHECK dout0_27 vdout0_27ck185 = 1.6 time = 1860
* CHECK dout0_28 vdout0_28ck185 = 1.6 time = 1860
* CHECK dout0_29 vdout0_29ck185 = 0 time = 1860
* CHECK dout0_30 vdout0_30ck185 = 1.6 time = 1860
* CHECK dout0_31 vdout0_31ck185 = 1.6 time = 1860
* CHECK dout0_32 vdout0_32ck185 = 0 time = 1860
* CHECK dout0_0 vdout0_0ck186 = 1.6 time = 1870
* CHECK dout0_1 vdout0_1ck186 = 0 time = 1870
* CHECK dout0_2 vdout0_2ck186 = 0 time = 1870
* CHECK dout0_3 vdout0_3ck186 = 1.6 time = 1870
* CHECK dout0_4 vdout0_4ck186 = 0 time = 1870
* CHECK dout0_5 vdout0_5ck186 = 0 time = 1870
* CHECK dout0_6 vdout0_6ck186 = 0 time = 1870
* CHECK dout0_7 vdout0_7ck186 = 0 time = 1870
* CHECK dout0_8 vdout0_8ck186 = 1.6 time = 1870
* CHECK dout0_9 vdout0_9ck186 = 0 time = 1870
* CHECK dout0_10 vdout0_10ck186 = 1.6 time = 1870
* CHECK dout0_11 vdout0_11ck186 = 0 time = 1870
* CHECK dout0_12 vdout0_12ck186 = 1.6 time = 1870
* CHECK dout0_13 vdout0_13ck186 = 1.6 time = 1870
* CHECK dout0_14 vdout0_14ck186 = 0 time = 1870
* CHECK dout0_15 vdout0_15ck186 = 0 time = 1870
* CHECK dout0_16 vdout0_16ck186 = 1.6 time = 1870
* CHECK dout0_17 vdout0_17ck186 = 0 time = 1870
* CHECK dout0_18 vdout0_18ck186 = 0 time = 1870
* CHECK dout0_19 vdout0_19ck186 = 0 time = 1870
* CHECK dout0_20 vdout0_20ck186 = 0 time = 1870
* CHECK dout0_21 vdout0_21ck186 = 0 time = 1870
* CHECK dout0_22 vdout0_22ck186 = 0 time = 1870
* CHECK dout0_23 vdout0_23ck186 = 1.6 time = 1870
* CHECK dout0_24 vdout0_24ck186 = 0 time = 1870
* CHECK dout0_25 vdout0_25ck186 = 0 time = 1870
* CHECK dout0_26 vdout0_26ck186 = 0 time = 1870
* CHECK dout0_27 vdout0_27ck186 = 1.6 time = 1870
* CHECK dout0_28 vdout0_28ck186 = 0 time = 1870
* CHECK dout0_29 vdout0_29ck186 = 1.6 time = 1870
* CHECK dout0_30 vdout0_30ck186 = 0 time = 1870
* CHECK dout0_31 vdout0_31ck186 = 0 time = 1870
* CHECK dout0_32 vdout0_32ck186 = 0 time = 1870
* CHECK dout0_0 vdout0_0ck187 = 0 time = 1880
* CHECK dout0_1 vdout0_1ck187 = 0 time = 1880
* CHECK dout0_2 vdout0_2ck187 = 0 time = 1880
* CHECK dout0_3 vdout0_3ck187 = 1.6 time = 1880
* CHECK dout0_4 vdout0_4ck187 = 0 time = 1880
* CHECK dout0_5 vdout0_5ck187 = 1.6 time = 1880
* CHECK dout0_6 vdout0_6ck187 = 1.6 time = 1880
* CHECK dout0_7 vdout0_7ck187 = 1.6 time = 1880
* CHECK dout0_8 vdout0_8ck187 = 1.6 time = 1880
* CHECK dout0_9 vdout0_9ck187 = 0 time = 1880
* CHECK dout0_10 vdout0_10ck187 = 0 time = 1880
* CHECK dout0_11 vdout0_11ck187 = 1.6 time = 1880
* CHECK dout0_12 vdout0_12ck187 = 0 time = 1880
* CHECK dout0_13 vdout0_13ck187 = 0 time = 1880
* CHECK dout0_14 vdout0_14ck187 = 1.6 time = 1880
* CHECK dout0_15 vdout0_15ck187 = 1.6 time = 1880
* CHECK dout0_16 vdout0_16ck187 = 1.6 time = 1880
* CHECK dout0_17 vdout0_17ck187 = 1.6 time = 1880
* CHECK dout0_18 vdout0_18ck187 = 1.6 time = 1880
* CHECK dout0_19 vdout0_19ck187 = 0 time = 1880
* CHECK dout0_20 vdout0_20ck187 = 0 time = 1880
* CHECK dout0_21 vdout0_21ck187 = 1.6 time = 1880
* CHECK dout0_22 vdout0_22ck187 = 0 time = 1880
* CHECK dout0_23 vdout0_23ck187 = 0 time = 1880
* CHECK dout0_24 vdout0_24ck187 = 1.6 time = 1880
* CHECK dout0_25 vdout0_25ck187 = 0 time = 1880
* CHECK dout0_26 vdout0_26ck187 = 0 time = 1880
* CHECK dout0_27 vdout0_27ck187 = 1.6 time = 1880
* CHECK dout0_28 vdout0_28ck187 = 1.6 time = 1880
* CHECK dout0_29 vdout0_29ck187 = 0 time = 1880
* CHECK dout0_30 vdout0_30ck187 = 1.6 time = 1880
* CHECK dout0_31 vdout0_31ck187 = 1.6 time = 1880
* CHECK dout0_32 vdout0_32ck187 = 0 time = 1880
* CHECK dout1_0 vdout1_0ck187 = 1.6 time = 1880
* CHECK dout1_1 vdout1_1ck187 = 0 time = 1880
* CHECK dout1_2 vdout1_2ck187 = 0 time = 1880
* CHECK dout1_3 vdout1_3ck187 = 1.6 time = 1880
* CHECK dout1_4 vdout1_4ck187 = 0 time = 1880
* CHECK dout1_5 vdout1_5ck187 = 0 time = 1880
* CHECK dout1_6 vdout1_6ck187 = 0 time = 1880
* CHECK dout1_7 vdout1_7ck187 = 0 time = 1880
* CHECK dout1_8 vdout1_8ck187 = 1.6 time = 1880
* CHECK dout1_9 vdout1_9ck187 = 0 time = 1880
* CHECK dout1_10 vdout1_10ck187 = 1.6 time = 1880
* CHECK dout1_11 vdout1_11ck187 = 0 time = 1880
* CHECK dout1_12 vdout1_12ck187 = 1.6 time = 1880
* CHECK dout1_13 vdout1_13ck187 = 1.6 time = 1880
* CHECK dout1_14 vdout1_14ck187 = 0 time = 1880
* CHECK dout1_15 vdout1_15ck187 = 0 time = 1880
* CHECK dout1_16 vdout1_16ck187 = 1.6 time = 1880
* CHECK dout1_17 vdout1_17ck187 = 0 time = 1880
* CHECK dout1_18 vdout1_18ck187 = 0 time = 1880
* CHECK dout1_19 vdout1_19ck187 = 0 time = 1880
* CHECK dout1_20 vdout1_20ck187 = 0 time = 1880
* CHECK dout1_21 vdout1_21ck187 = 0 time = 1880
* CHECK dout1_22 vdout1_22ck187 = 0 time = 1880
* CHECK dout1_23 vdout1_23ck187 = 1.6 time = 1880
* CHECK dout1_24 vdout1_24ck187 = 0 time = 1880
* CHECK dout1_25 vdout1_25ck187 = 0 time = 1880
* CHECK dout1_26 vdout1_26ck187 = 0 time = 1880
* CHECK dout1_27 vdout1_27ck187 = 1.6 time = 1880
* CHECK dout1_28 vdout1_28ck187 = 0 time = 1880
* CHECK dout1_29 vdout1_29ck187 = 1.6 time = 1880
* CHECK dout1_30 vdout1_30ck187 = 0 time = 1880
* CHECK dout1_31 vdout1_31ck187 = 0 time = 1880
* CHECK dout1_32 vdout1_32ck187 = 0 time = 1880
* CHECK dout0_0 vdout0_0ck189 = 1.6 time = 1900
* CHECK dout0_1 vdout0_1ck189 = 1.6 time = 1900
* CHECK dout0_2 vdout0_2ck189 = 0 time = 1900
* CHECK dout0_3 vdout0_3ck189 = 1.6 time = 1900
* CHECK dout0_4 vdout0_4ck189 = 0 time = 1900
* CHECK dout0_5 vdout0_5ck189 = 0 time = 1900
* CHECK dout0_6 vdout0_6ck189 = 0 time = 1900
* CHECK dout0_7 vdout0_7ck189 = 1.6 time = 1900
* CHECK dout0_8 vdout0_8ck189 = 0 time = 1900
* CHECK dout0_9 vdout0_9ck189 = 0 time = 1900
* CHECK dout0_10 vdout0_10ck189 = 1.6 time = 1900
* CHECK dout0_11 vdout0_11ck189 = 0 time = 1900
* CHECK dout0_12 vdout0_12ck189 = 1.6 time = 1900
* CHECK dout0_13 vdout0_13ck189 = 1.6 time = 1900
* CHECK dout0_14 vdout0_14ck189 = 0 time = 1900
* CHECK dout0_15 vdout0_15ck189 = 0 time = 1900
* CHECK dout0_16 vdout0_16ck189 = 0 time = 1900
* CHECK dout0_17 vdout0_17ck189 = 0 time = 1900
* CHECK dout0_18 vdout0_18ck189 = 1.6 time = 1900
* CHECK dout0_19 vdout0_19ck189 = 1.6 time = 1900
* CHECK dout0_20 vdout0_20ck189 = 1.6 time = 1900
* CHECK dout0_21 vdout0_21ck189 = 1.6 time = 1900
* CHECK dout0_22 vdout0_22ck189 = 1.6 time = 1900
* CHECK dout0_23 vdout0_23ck189 = 1.6 time = 1900
* CHECK dout0_24 vdout0_24ck189 = 0 time = 1900
* CHECK dout0_25 vdout0_25ck189 = 1.6 time = 1900
* CHECK dout0_26 vdout0_26ck189 = 1.6 time = 1900
* CHECK dout0_27 vdout0_27ck189 = 0 time = 1900
* CHECK dout0_28 vdout0_28ck189 = 0 time = 1900
* CHECK dout0_29 vdout0_29ck189 = 0 time = 1900
* CHECK dout0_30 vdout0_30ck189 = 1.6 time = 1900
* CHECK dout0_31 vdout0_31ck189 = 1.6 time = 1900
* CHECK dout0_32 vdout0_32ck189 = 0 time = 1900
* CHECK dout1_0 vdout1_0ck189 = 1.6 time = 1900
* CHECK dout1_1 vdout1_1ck189 = 1.6 time = 1900
* CHECK dout1_2 vdout1_2ck189 = 0 time = 1900
* CHECK dout1_3 vdout1_3ck189 = 1.6 time = 1900
* CHECK dout1_4 vdout1_4ck189 = 0 time = 1900
* CHECK dout1_5 vdout1_5ck189 = 0 time = 1900
* CHECK dout1_6 vdout1_6ck189 = 0 time = 1900
* CHECK dout1_7 vdout1_7ck189 = 1.6 time = 1900
* CHECK dout1_8 vdout1_8ck189 = 0 time = 1900
* CHECK dout1_9 vdout1_9ck189 = 0 time = 1900
* CHECK dout1_10 vdout1_10ck189 = 1.6 time = 1900
* CHECK dout1_11 vdout1_11ck189 = 0 time = 1900
* CHECK dout1_12 vdout1_12ck189 = 1.6 time = 1900
* CHECK dout1_13 vdout1_13ck189 = 1.6 time = 1900
* CHECK dout1_14 vdout1_14ck189 = 0 time = 1900
* CHECK dout1_15 vdout1_15ck189 = 0 time = 1900
* CHECK dout1_16 vdout1_16ck189 = 0 time = 1900
* CHECK dout1_17 vdout1_17ck189 = 0 time = 1900
* CHECK dout1_18 vdout1_18ck189 = 1.6 time = 1900
* CHECK dout1_19 vdout1_19ck189 = 1.6 time = 1900
* CHECK dout1_20 vdout1_20ck189 = 1.6 time = 1900
* CHECK dout1_21 vdout1_21ck189 = 1.6 time = 1900
* CHECK dout1_22 vdout1_22ck189 = 1.6 time = 1900
* CHECK dout1_23 vdout1_23ck189 = 1.6 time = 1900
* CHECK dout1_24 vdout1_24ck189 = 0 time = 1900
* CHECK dout1_25 vdout1_25ck189 = 1.6 time = 1900
* CHECK dout1_26 vdout1_26ck189 = 1.6 time = 1900
* CHECK dout1_27 vdout1_27ck189 = 0 time = 1900
* CHECK dout1_28 vdout1_28ck189 = 0 time = 1900
* CHECK dout1_29 vdout1_29ck189 = 0 time = 1900
* CHECK dout1_30 vdout1_30ck189 = 1.6 time = 1900
* CHECK dout1_31 vdout1_31ck189 = 1.6 time = 1900
* CHECK dout1_32 vdout1_32ck189 = 0 time = 1900
* CHECK dout0_0 vdout0_0ck191 = 0 time = 1920
* CHECK dout0_1 vdout0_1ck191 = 0 time = 1920
* CHECK dout0_2 vdout0_2ck191 = 0 time = 1920
* CHECK dout0_3 vdout0_3ck191 = 1.6 time = 1920
* CHECK dout0_4 vdout0_4ck191 = 0 time = 1920
* CHECK dout0_5 vdout0_5ck191 = 1.6 time = 1920
* CHECK dout0_6 vdout0_6ck191 = 1.6 time = 1920
* CHECK dout0_7 vdout0_7ck191 = 1.6 time = 1920
* CHECK dout0_8 vdout0_8ck191 = 1.6 time = 1920
* CHECK dout0_9 vdout0_9ck191 = 0 time = 1920
* CHECK dout0_10 vdout0_10ck191 = 0 time = 1920
* CHECK dout0_11 vdout0_11ck191 = 1.6 time = 1920
* CHECK dout0_12 vdout0_12ck191 = 0 time = 1920
* CHECK dout0_13 vdout0_13ck191 = 0 time = 1920
* CHECK dout0_14 vdout0_14ck191 = 1.6 time = 1920
* CHECK dout0_15 vdout0_15ck191 = 1.6 time = 1920
* CHECK dout0_16 vdout0_16ck191 = 1.6 time = 1920
* CHECK dout0_17 vdout0_17ck191 = 1.6 time = 1920
* CHECK dout0_18 vdout0_18ck191 = 1.6 time = 1920
* CHECK dout0_19 vdout0_19ck191 = 0 time = 1920
* CHECK dout0_20 vdout0_20ck191 = 0 time = 1920
* CHECK dout0_21 vdout0_21ck191 = 1.6 time = 1920
* CHECK dout0_22 vdout0_22ck191 = 0 time = 1920
* CHECK dout0_23 vdout0_23ck191 = 0 time = 1920
* CHECK dout0_24 vdout0_24ck191 = 1.6 time = 1920
* CHECK dout0_25 vdout0_25ck191 = 0 time = 1920
* CHECK dout0_26 vdout0_26ck191 = 0 time = 1920
* CHECK dout0_27 vdout0_27ck191 = 1.6 time = 1920
* CHECK dout0_28 vdout0_28ck191 = 1.6 time = 1920
* CHECK dout0_29 vdout0_29ck191 = 0 time = 1920
* CHECK dout0_30 vdout0_30ck191 = 1.6 time = 1920
* CHECK dout0_31 vdout0_31ck191 = 1.6 time = 1920
* CHECK dout0_32 vdout0_32ck191 = 0 time = 1920
* CHECK dout0_0 vdout0_0ck192 = 0 time = 1930
* CHECK dout0_1 vdout0_1ck192 = 0 time = 1930
* CHECK dout0_2 vdout0_2ck192 = 0 time = 1930
* CHECK dout0_3 vdout0_3ck192 = 1.6 time = 1930
* CHECK dout0_4 vdout0_4ck192 = 0 time = 1930
* CHECK dout0_5 vdout0_5ck192 = 1.6 time = 1930
* CHECK dout0_6 vdout0_6ck192 = 1.6 time = 1930
* CHECK dout0_7 vdout0_7ck192 = 1.6 time = 1930
* CHECK dout0_8 vdout0_8ck192 = 1.6 time = 1930
* CHECK dout0_9 vdout0_9ck192 = 0 time = 1930
* CHECK dout0_10 vdout0_10ck192 = 0 time = 1930
* CHECK dout0_11 vdout0_11ck192 = 1.6 time = 1930
* CHECK dout0_12 vdout0_12ck192 = 0 time = 1930
* CHECK dout0_13 vdout0_13ck192 = 0 time = 1930
* CHECK dout0_14 vdout0_14ck192 = 1.6 time = 1930
* CHECK dout0_15 vdout0_15ck192 = 1.6 time = 1930
* CHECK dout0_16 vdout0_16ck192 = 1.6 time = 1930
* CHECK dout0_17 vdout0_17ck192 = 1.6 time = 1930
* CHECK dout0_18 vdout0_18ck192 = 1.6 time = 1930
* CHECK dout0_19 vdout0_19ck192 = 0 time = 1930
* CHECK dout0_20 vdout0_20ck192 = 0 time = 1930
* CHECK dout0_21 vdout0_21ck192 = 1.6 time = 1930
* CHECK dout0_22 vdout0_22ck192 = 0 time = 1930
* CHECK dout0_23 vdout0_23ck192 = 0 time = 1930
* CHECK dout0_24 vdout0_24ck192 = 1.6 time = 1930
* CHECK dout0_25 vdout0_25ck192 = 0 time = 1930
* CHECK dout0_26 vdout0_26ck192 = 0 time = 1930
* CHECK dout0_27 vdout0_27ck192 = 1.6 time = 1930
* CHECK dout0_28 vdout0_28ck192 = 1.6 time = 1930
* CHECK dout0_29 vdout0_29ck192 = 0 time = 1930
* CHECK dout0_30 vdout0_30ck192 = 1.6 time = 1930
* CHECK dout0_31 vdout0_31ck192 = 1.6 time = 1930
* CHECK dout0_32 vdout0_32ck192 = 0 time = 1930
* CHECK dout1_0 vdout1_0ck192 = 1.6 time = 1930
* CHECK dout1_1 vdout1_1ck192 = 1.6 time = 1930
* CHECK dout1_2 vdout1_2ck192 = 0 time = 1930
* CHECK dout1_3 vdout1_3ck192 = 1.6 time = 1930
* CHECK dout1_4 vdout1_4ck192 = 0 time = 1930
* CHECK dout1_5 vdout1_5ck192 = 0 time = 1930
* CHECK dout1_6 vdout1_6ck192 = 0 time = 1930
* CHECK dout1_7 vdout1_7ck192 = 1.6 time = 1930
* CHECK dout1_8 vdout1_8ck192 = 0 time = 1930
* CHECK dout1_9 vdout1_9ck192 = 0 time = 1930
* CHECK dout1_10 vdout1_10ck192 = 1.6 time = 1930
* CHECK dout1_11 vdout1_11ck192 = 0 time = 1930
* CHECK dout1_12 vdout1_12ck192 = 1.6 time = 1930
* CHECK dout1_13 vdout1_13ck192 = 1.6 time = 1930
* CHECK dout1_14 vdout1_14ck192 = 0 time = 1930
* CHECK dout1_15 vdout1_15ck192 = 0 time = 1930
* CHECK dout1_16 vdout1_16ck192 = 0 time = 1930
* CHECK dout1_17 vdout1_17ck192 = 0 time = 1930
* CHECK dout1_18 vdout1_18ck192 = 1.6 time = 1930
* CHECK dout1_19 vdout1_19ck192 = 1.6 time = 1930
* CHECK dout1_20 vdout1_20ck192 = 1.6 time = 1930
* CHECK dout1_21 vdout1_21ck192 = 1.6 time = 1930
* CHECK dout1_22 vdout1_22ck192 = 1.6 time = 1930
* CHECK dout1_23 vdout1_23ck192 = 1.6 time = 1930
* CHECK dout1_24 vdout1_24ck192 = 0 time = 1930
* CHECK dout1_25 vdout1_25ck192 = 1.6 time = 1930
* CHECK dout1_26 vdout1_26ck192 = 1.6 time = 1930
* CHECK dout1_27 vdout1_27ck192 = 0 time = 1930
* CHECK dout1_28 vdout1_28ck192 = 0 time = 1930
* CHECK dout1_29 vdout1_29ck192 = 0 time = 1930
* CHECK dout1_30 vdout1_30ck192 = 1.6 time = 1930
* CHECK dout1_31 vdout1_31ck192 = 1.6 time = 1930
* CHECK dout1_32 vdout1_32ck192 = 0 time = 1930
* CHECK dout0_0 vdout0_0ck193 = 1.6 time = 1940
* CHECK dout0_1 vdout0_1ck193 = 1.6 time = 1940
* CHECK dout0_2 vdout0_2ck193 = 0 time = 1940
* CHECK dout0_3 vdout0_3ck193 = 1.6 time = 1940
* CHECK dout0_4 vdout0_4ck193 = 0 time = 1940
* CHECK dout0_5 vdout0_5ck193 = 0 time = 1940
* CHECK dout0_6 vdout0_6ck193 = 0 time = 1940
* CHECK dout0_7 vdout0_7ck193 = 1.6 time = 1940
* CHECK dout0_8 vdout0_8ck193 = 0 time = 1940
* CHECK dout0_9 vdout0_9ck193 = 0 time = 1940
* CHECK dout0_10 vdout0_10ck193 = 1.6 time = 1940
* CHECK dout0_11 vdout0_11ck193 = 0 time = 1940
* CHECK dout0_12 vdout0_12ck193 = 1.6 time = 1940
* CHECK dout0_13 vdout0_13ck193 = 1.6 time = 1940
* CHECK dout0_14 vdout0_14ck193 = 0 time = 1940
* CHECK dout0_15 vdout0_15ck193 = 0 time = 1940
* CHECK dout0_16 vdout0_16ck193 = 0 time = 1940
* CHECK dout0_17 vdout0_17ck193 = 0 time = 1940
* CHECK dout0_18 vdout0_18ck193 = 1.6 time = 1940
* CHECK dout0_19 vdout0_19ck193 = 1.6 time = 1940
* CHECK dout0_20 vdout0_20ck193 = 1.6 time = 1940
* CHECK dout0_21 vdout0_21ck193 = 1.6 time = 1940
* CHECK dout0_22 vdout0_22ck193 = 1.6 time = 1940
* CHECK dout0_23 vdout0_23ck193 = 1.6 time = 1940
* CHECK dout0_24 vdout0_24ck193 = 0 time = 1940
* CHECK dout0_25 vdout0_25ck193 = 1.6 time = 1940
* CHECK dout0_26 vdout0_26ck193 = 1.6 time = 1940
* CHECK dout0_27 vdout0_27ck193 = 0 time = 1940
* CHECK dout0_28 vdout0_28ck193 = 0 time = 1940
* CHECK dout0_29 vdout0_29ck193 = 0 time = 1940
* CHECK dout0_30 vdout0_30ck193 = 1.6 time = 1940
* CHECK dout0_31 vdout0_31ck193 = 1.6 time = 1940
* CHECK dout0_32 vdout0_32ck193 = 0 time = 1940
* CHECK dout1_0 vdout1_0ck193 = 0 time = 1940
* CHECK dout1_1 vdout1_1ck193 = 0 time = 1940
* CHECK dout1_2 vdout1_2ck193 = 0 time = 1940
* CHECK dout1_3 vdout1_3ck193 = 1.6 time = 1940
* CHECK dout1_4 vdout1_4ck193 = 0 time = 1940
* CHECK dout1_5 vdout1_5ck193 = 1.6 time = 1940
* CHECK dout1_6 vdout1_6ck193 = 1.6 time = 1940
* CHECK dout1_7 vdout1_7ck193 = 1.6 time = 1940
* CHECK dout1_8 vdout1_8ck193 = 1.6 time = 1940
* CHECK dout1_9 vdout1_9ck193 = 0 time = 1940
* CHECK dout1_10 vdout1_10ck193 = 0 time = 1940
* CHECK dout1_11 vdout1_11ck193 = 1.6 time = 1940
* CHECK dout1_12 vdout1_12ck193 = 0 time = 1940
* CHECK dout1_13 vdout1_13ck193 = 0 time = 1940
* CHECK dout1_14 vdout1_14ck193 = 1.6 time = 1940
* CHECK dout1_15 vdout1_15ck193 = 1.6 time = 1940
* CHECK dout1_16 vdout1_16ck193 = 1.6 time = 1940
* CHECK dout1_17 vdout1_17ck193 = 1.6 time = 1940
* CHECK dout1_18 vdout1_18ck193 = 1.6 time = 1940
* CHECK dout1_19 vdout1_19ck193 = 0 time = 1940
* CHECK dout1_20 vdout1_20ck193 = 0 time = 1940
* CHECK dout1_21 vdout1_21ck193 = 1.6 time = 1940
* CHECK dout1_22 vdout1_22ck193 = 0 time = 1940
* CHECK dout1_23 vdout1_23ck193 = 0 time = 1940
* CHECK dout1_24 vdout1_24ck193 = 1.6 time = 1940
* CHECK dout1_25 vdout1_25ck193 = 0 time = 1940
* CHECK dout1_26 vdout1_26ck193 = 0 time = 1940
* CHECK dout1_27 vdout1_27ck193 = 1.6 time = 1940
* CHECK dout1_28 vdout1_28ck193 = 1.6 time = 1940
* CHECK dout1_29 vdout1_29ck193 = 0 time = 1940
* CHECK dout1_30 vdout1_30ck193 = 1.6 time = 1940
* CHECK dout1_31 vdout1_31ck193 = 1.6 time = 1940
* CHECK dout1_32 vdout1_32ck193 = 0 time = 1940
* CHECK dout0_0 vdout0_0ck195 = 1.6 time = 1960
* CHECK dout0_1 vdout0_1ck195 = 1.6 time = 1960
* CHECK dout0_2 vdout0_2ck195 = 0 time = 1960
* CHECK dout0_3 vdout0_3ck195 = 1.6 time = 1960
* CHECK dout0_4 vdout0_4ck195 = 0 time = 1960
* CHECK dout0_5 vdout0_5ck195 = 0 time = 1960
* CHECK dout0_6 vdout0_6ck195 = 0 time = 1960
* CHECK dout0_7 vdout0_7ck195 = 1.6 time = 1960
* CHECK dout0_8 vdout0_8ck195 = 0 time = 1960
* CHECK dout0_9 vdout0_9ck195 = 0 time = 1960
* CHECK dout0_10 vdout0_10ck195 = 1.6 time = 1960
* CHECK dout0_11 vdout0_11ck195 = 0 time = 1960
* CHECK dout0_12 vdout0_12ck195 = 1.6 time = 1960
* CHECK dout0_13 vdout0_13ck195 = 1.6 time = 1960
* CHECK dout0_14 vdout0_14ck195 = 0 time = 1960
* CHECK dout0_15 vdout0_15ck195 = 0 time = 1960
* CHECK dout0_16 vdout0_16ck195 = 0 time = 1960
* CHECK dout0_17 vdout0_17ck195 = 0 time = 1960
* CHECK dout0_18 vdout0_18ck195 = 1.6 time = 1960
* CHECK dout0_19 vdout0_19ck195 = 1.6 time = 1960
* CHECK dout0_20 vdout0_20ck195 = 1.6 time = 1960
* CHECK dout0_21 vdout0_21ck195 = 1.6 time = 1960
* CHECK dout0_22 vdout0_22ck195 = 1.6 time = 1960
* CHECK dout0_23 vdout0_23ck195 = 1.6 time = 1960
* CHECK dout0_24 vdout0_24ck195 = 0 time = 1960
* CHECK dout0_25 vdout0_25ck195 = 1.6 time = 1960
* CHECK dout0_26 vdout0_26ck195 = 1.6 time = 1960
* CHECK dout0_27 vdout0_27ck195 = 0 time = 1960
* CHECK dout0_28 vdout0_28ck195 = 0 time = 1960
* CHECK dout0_29 vdout0_29ck195 = 0 time = 1960
* CHECK dout0_30 vdout0_30ck195 = 1.6 time = 1960
* CHECK dout0_31 vdout0_31ck195 = 1.6 time = 1960
* CHECK dout0_32 vdout0_32ck195 = 0 time = 1960
* CHECK dout1_0 vdout1_0ck195 = 0 time = 1960
* CHECK dout1_1 vdout1_1ck195 = 0 time = 1960
* CHECK dout1_2 vdout1_2ck195 = 1.6 time = 1960
* CHECK dout1_3 vdout1_3ck195 = 1.6 time = 1960
* CHECK dout1_4 vdout1_4ck195 = 0 time = 1960
* CHECK dout1_5 vdout1_5ck195 = 0 time = 1960
* CHECK dout1_6 vdout1_6ck195 = 0 time = 1960
* CHECK dout1_7 vdout1_7ck195 = 0 time = 1960
* CHECK dout1_8 vdout1_8ck195 = 1.6 time = 1960
* CHECK dout1_9 vdout1_9ck195 = 1.6 time = 1960
* CHECK dout1_10 vdout1_10ck195 = 1.6 time = 1960
* CHECK dout1_11 vdout1_11ck195 = 1.6 time = 1960
* CHECK dout1_12 vdout1_12ck195 = 1.6 time = 1960
* CHECK dout1_13 vdout1_13ck195 = 1.6 time = 1960
* CHECK dout1_14 vdout1_14ck195 = 1.6 time = 1960
* CHECK dout1_15 vdout1_15ck195 = 1.6 time = 1960
* CHECK dout1_16 vdout1_16ck195 = 1.6 time = 1960
* CHECK dout1_17 vdout1_17ck195 = 1.6 time = 1960
* CHECK dout1_18 vdout1_18ck195 = 0 time = 1960
* CHECK dout1_19 vdout1_19ck195 = 1.6 time = 1960
* CHECK dout1_20 vdout1_20ck195 = 1.6 time = 1960
* CHECK dout1_21 vdout1_21ck195 = 0 time = 1960
* CHECK dout1_22 vdout1_22ck195 = 1.6 time = 1960
* CHECK dout1_23 vdout1_23ck195 = 0 time = 1960
* CHECK dout1_24 vdout1_24ck195 = 0 time = 1960
* CHECK dout1_25 vdout1_25ck195 = 0 time = 1960
* CHECK dout1_26 vdout1_26ck195 = 1.6 time = 1960
* CHECK dout1_27 vdout1_27ck195 = 0 time = 1960
* CHECK dout1_28 vdout1_28ck195 = 0 time = 1960
* CHECK dout1_29 vdout1_29ck195 = 0 time = 1960
* CHECK dout1_30 vdout1_30ck195 = 1.6 time = 1960
* CHECK dout1_31 vdout1_31ck195 = 1.6 time = 1960
* CHECK dout1_32 vdout1_32ck195 = 0 time = 1960
* CHECK dout1_0 vdout1_0ck196 = 0 time = 1970
* CHECK dout1_1 vdout1_1ck196 = 0 time = 1970
* CHECK dout1_2 vdout1_2ck196 = 1.6 time = 1970
* CHECK dout1_3 vdout1_3ck196 = 1.6 time = 1970
* CHECK dout1_4 vdout1_4ck196 = 0 time = 1970
* CHECK dout1_5 vdout1_5ck196 = 0 time = 1970
* CHECK dout1_6 vdout1_6ck196 = 0 time = 1970
* CHECK dout1_7 vdout1_7ck196 = 0 time = 1970
* CHECK dout1_8 vdout1_8ck196 = 1.6 time = 1970
* CHECK dout1_9 vdout1_9ck196 = 1.6 time = 1970
* CHECK dout1_10 vdout1_10ck196 = 1.6 time = 1970
* CHECK dout1_11 vdout1_11ck196 = 1.6 time = 1970
* CHECK dout1_12 vdout1_12ck196 = 1.6 time = 1970
* CHECK dout1_13 vdout1_13ck196 = 1.6 time = 1970
* CHECK dout1_14 vdout1_14ck196 = 1.6 time = 1970
* CHECK dout1_15 vdout1_15ck196 = 1.6 time = 1970
* CHECK dout1_16 vdout1_16ck196 = 1.6 time = 1970
* CHECK dout1_17 vdout1_17ck196 = 1.6 time = 1970
* CHECK dout1_18 vdout1_18ck196 = 0 time = 1970
* CHECK dout1_19 vdout1_19ck196 = 1.6 time = 1970
* CHECK dout1_20 vdout1_20ck196 = 1.6 time = 1970
* CHECK dout1_21 vdout1_21ck196 = 0 time = 1970
* CHECK dout1_22 vdout1_22ck196 = 1.6 time = 1970
* CHECK dout1_23 vdout1_23ck196 = 0 time = 1970
* CHECK dout1_24 vdout1_24ck196 = 0 time = 1970
* CHECK dout1_25 vdout1_25ck196 = 0 time = 1970
* CHECK dout1_26 vdout1_26ck196 = 1.6 time = 1970
* CHECK dout1_27 vdout1_27ck196 = 0 time = 1970
* CHECK dout1_28 vdout1_28ck196 = 0 time = 1970
* CHECK dout1_29 vdout1_29ck196 = 0 time = 1970
* CHECK dout1_30 vdout1_30ck196 = 1.6 time = 1970
* CHECK dout1_31 vdout1_31ck196 = 1.6 time = 1970
* CHECK dout1_32 vdout1_32ck196 = 0 time = 1970
* CHECK dout0_0 vdout0_0ck197 = 1.6 time = 1980
* CHECK dout0_1 vdout0_1ck197 = 0 time = 1980
* CHECK dout0_2 vdout0_2ck197 = 0 time = 1980
* CHECK dout0_3 vdout0_3ck197 = 1.6 time = 1980
* CHECK dout0_4 vdout0_4ck197 = 0 time = 1980
* CHECK dout0_5 vdout0_5ck197 = 0 time = 1980
* CHECK dout0_6 vdout0_6ck197 = 0 time = 1980
* CHECK dout0_7 vdout0_7ck197 = 0 time = 1980
* CHECK dout0_8 vdout0_8ck197 = 1.6 time = 1980
* CHECK dout0_9 vdout0_9ck197 = 0 time = 1980
* CHECK dout0_10 vdout0_10ck197 = 1.6 time = 1980
* CHECK dout0_11 vdout0_11ck197 = 0 time = 1980
* CHECK dout0_12 vdout0_12ck197 = 1.6 time = 1980
* CHECK dout0_13 vdout0_13ck197 = 1.6 time = 1980
* CHECK dout0_14 vdout0_14ck197 = 0 time = 1980
* CHECK dout0_15 vdout0_15ck197 = 0 time = 1980
* CHECK dout0_16 vdout0_16ck197 = 1.6 time = 1980
* CHECK dout0_17 vdout0_17ck197 = 0 time = 1980
* CHECK dout0_18 vdout0_18ck197 = 0 time = 1980
* CHECK dout0_19 vdout0_19ck197 = 0 time = 1980
* CHECK dout0_20 vdout0_20ck197 = 0 time = 1980
* CHECK dout0_21 vdout0_21ck197 = 0 time = 1980
* CHECK dout0_22 vdout0_22ck197 = 0 time = 1980
* CHECK dout0_23 vdout0_23ck197 = 1.6 time = 1980
* CHECK dout0_24 vdout0_24ck197 = 0 time = 1980
* CHECK dout0_25 vdout0_25ck197 = 0 time = 1980
* CHECK dout0_26 vdout0_26ck197 = 0 time = 1980
* CHECK dout0_27 vdout0_27ck197 = 1.6 time = 1980
* CHECK dout0_28 vdout0_28ck197 = 0 time = 1980
* CHECK dout0_29 vdout0_29ck197 = 1.6 time = 1980
* CHECK dout0_30 vdout0_30ck197 = 0 time = 1980
* CHECK dout0_31 vdout0_31ck197 = 0 time = 1980
* CHECK dout0_32 vdout0_32ck197 = 0 time = 1980
* CHECK dout0_0 vdout0_0ck198 = 0 time = 1990
* CHECK dout0_1 vdout0_1ck198 = 0 time = 1990
* CHECK dout0_2 vdout0_2ck198 = 1.6 time = 1990
* CHECK dout0_3 vdout0_3ck198 = 1.6 time = 1990
* CHECK dout0_4 vdout0_4ck198 = 0 time = 1990
* CHECK dout0_5 vdout0_5ck198 = 0 time = 1990
* CHECK dout0_6 vdout0_6ck198 = 0 time = 1990
* CHECK dout0_7 vdout0_7ck198 = 0 time = 1990
* CHECK dout0_8 vdout0_8ck198 = 1.6 time = 1990
* CHECK dout0_9 vdout0_9ck198 = 1.6 time = 1990
* CHECK dout0_10 vdout0_10ck198 = 1.6 time = 1990
* CHECK dout0_11 vdout0_11ck198 = 1.6 time = 1990
* CHECK dout0_12 vdout0_12ck198 = 1.6 time = 1990
* CHECK dout0_13 vdout0_13ck198 = 1.6 time = 1990
* CHECK dout0_14 vdout0_14ck198 = 1.6 time = 1990
* CHECK dout0_15 vdout0_15ck198 = 1.6 time = 1990
* CHECK dout0_16 vdout0_16ck198 = 1.6 time = 1990
* CHECK dout0_17 vdout0_17ck198 = 1.6 time = 1990
* CHECK dout0_18 vdout0_18ck198 = 0 time = 1990
* CHECK dout0_19 vdout0_19ck198 = 1.6 time = 1990
* CHECK dout0_20 vdout0_20ck198 = 1.6 time = 1990
* CHECK dout0_21 vdout0_21ck198 = 0 time = 1990
* CHECK dout0_22 vdout0_22ck198 = 1.6 time = 1990
* CHECK dout0_23 vdout0_23ck198 = 0 time = 1990
* CHECK dout0_24 vdout0_24ck198 = 0 time = 1990
* CHECK dout0_25 vdout0_25ck198 = 0 time = 1990
* CHECK dout0_26 vdout0_26ck198 = 1.6 time = 1990
* CHECK dout0_27 vdout0_27ck198 = 0 time = 1990
* CHECK dout0_28 vdout0_28ck198 = 0 time = 1990
* CHECK dout0_29 vdout0_29ck198 = 0 time = 1990
* CHECK dout0_30 vdout0_30ck198 = 1.6 time = 1990
* CHECK dout0_31 vdout0_31ck198 = 1.6 time = 1990
* CHECK dout0_32 vdout0_32ck198 = 0 time = 1990
* CHECK dout0_0 vdout0_0ck200 = 0 time = 2010
* CHECK dout0_1 vdout0_1ck200 = 1.6 time = 2010
* CHECK dout0_2 vdout0_2ck200 = 0 time = 2010
* CHECK dout0_3 vdout0_3ck200 = 1.6 time = 2010
* CHECK dout0_4 vdout0_4ck200 = 0 time = 2010
* CHECK dout0_5 vdout0_5ck200 = 0 time = 2010
* CHECK dout0_6 vdout0_6ck200 = 0 time = 2010
* CHECK dout0_7 vdout0_7ck200 = 0 time = 2010
* CHECK dout0_8 vdout0_8ck200 = 1.6 time = 2010
* CHECK dout0_9 vdout0_9ck200 = 0 time = 2010
* CHECK dout0_10 vdout0_10ck200 = 0 time = 2010
* CHECK dout0_11 vdout0_11ck200 = 0 time = 2010
* CHECK dout0_12 vdout0_12ck200 = 0 time = 2010
* CHECK dout0_13 vdout0_13ck200 = 0 time = 2010
* CHECK dout0_14 vdout0_14ck200 = 1.6 time = 2010
* CHECK dout0_15 vdout0_15ck200 = 0 time = 2010
* CHECK dout0_16 vdout0_16ck200 = 1.6 time = 2010
* CHECK dout0_17 vdout0_17ck200 = 0 time = 2010
* CHECK dout0_18 vdout0_18ck200 = 1.6 time = 2010
* CHECK dout0_19 vdout0_19ck200 = 1.6 time = 2010
* CHECK dout0_20 vdout0_20ck200 = 0 time = 2010
* CHECK dout0_21 vdout0_21ck200 = 0 time = 2010
* CHECK dout0_22 vdout0_22ck200 = 0 time = 2010
* CHECK dout0_23 vdout0_23ck200 = 0 time = 2010
* CHECK dout0_24 vdout0_24ck200 = 0 time = 2010
* CHECK dout0_25 vdout0_25ck200 = 1.6 time = 2010
* CHECK dout0_26 vdout0_26ck200 = 0 time = 2010
* CHECK dout0_27 vdout0_27ck200 = 1.6 time = 2010
* CHECK dout0_28 vdout0_28ck200 = 1.6 time = 2010
* CHECK dout0_29 vdout0_29ck200 = 0 time = 2010
* CHECK dout0_30 vdout0_30ck200 = 0 time = 2010
* CHECK dout0_31 vdout0_31ck200 = 1.6 time = 2010
* CHECK dout0_32 vdout0_32ck200 = 0 time = 2010
* CHECK dout1_0 vdout1_0ck200 = 0 time = 2010
* CHECK dout1_1 vdout1_1ck200 = 0 time = 2010
* CHECK dout1_2 vdout1_2ck200 = 0 time = 2010
* CHECK dout1_3 vdout1_3ck200 = 1.6 time = 2010
* CHECK dout1_4 vdout1_4ck200 = 0 time = 2010
* CHECK dout1_5 vdout1_5ck200 = 1.6 time = 2010
* CHECK dout1_6 vdout1_6ck200 = 1.6 time = 2010
* CHECK dout1_7 vdout1_7ck200 = 1.6 time = 2010
* CHECK dout1_8 vdout1_8ck200 = 1.6 time = 2010
* CHECK dout1_9 vdout1_9ck200 = 0 time = 2010
* CHECK dout1_10 vdout1_10ck200 = 0 time = 2010
* CHECK dout1_11 vdout1_11ck200 = 1.6 time = 2010
* CHECK dout1_12 vdout1_12ck200 = 0 time = 2010
* CHECK dout1_13 vdout1_13ck200 = 0 time = 2010
* CHECK dout1_14 vdout1_14ck200 = 1.6 time = 2010
* CHECK dout1_15 vdout1_15ck200 = 1.6 time = 2010
* CHECK dout1_16 vdout1_16ck200 = 1.6 time = 2010
* CHECK dout1_17 vdout1_17ck200 = 1.6 time = 2010
* CHECK dout1_18 vdout1_18ck200 = 1.6 time = 2010
* CHECK dout1_19 vdout1_19ck200 = 0 time = 2010
* CHECK dout1_20 vdout1_20ck200 = 0 time = 2010
* CHECK dout1_21 vdout1_21ck200 = 1.6 time = 2010
* CHECK dout1_22 vdout1_22ck200 = 0 time = 2010
* CHECK dout1_23 vdout1_23ck200 = 0 time = 2010
* CHECK dout1_24 vdout1_24ck200 = 1.6 time = 2010
* CHECK dout1_25 vdout1_25ck200 = 0 time = 2010
* CHECK dout1_26 vdout1_26ck200 = 0 time = 2010
* CHECK dout1_27 vdout1_27ck200 = 1.6 time = 2010
* CHECK dout1_28 vdout1_28ck200 = 1.6 time = 2010
* CHECK dout1_29 vdout1_29ck200 = 0 time = 2010
* CHECK dout1_30 vdout1_30ck200 = 1.6 time = 2010
* CHECK dout1_31 vdout1_31ck200 = 1.6 time = 2010
* CHECK dout1_32 vdout1_32ck200 = 0 time = 2010
* CHECK dout0_0 vdout0_0ck201 = 0 time = 2020
* CHECK dout0_1 vdout0_1ck201 = 0 time = 2020
* CHECK dout0_2 vdout0_2ck201 = 0 time = 2020
* CHECK dout0_3 vdout0_3ck201 = 1.6 time = 2020
* CHECK dout0_4 vdout0_4ck201 = 0 time = 2020
* CHECK dout0_5 vdout0_5ck201 = 1.6 time = 2020
* CHECK dout0_6 vdout0_6ck201 = 1.6 time = 2020
* CHECK dout0_7 vdout0_7ck201 = 1.6 time = 2020
* CHECK dout0_8 vdout0_8ck201 = 1.6 time = 2020
* CHECK dout0_9 vdout0_9ck201 = 0 time = 2020
* CHECK dout0_10 vdout0_10ck201 = 0 time = 2020
* CHECK dout0_11 vdout0_11ck201 = 1.6 time = 2020
* CHECK dout0_12 vdout0_12ck201 = 0 time = 2020
* CHECK dout0_13 vdout0_13ck201 = 0 time = 2020
* CHECK dout0_14 vdout0_14ck201 = 1.6 time = 2020
* CHECK dout0_15 vdout0_15ck201 = 1.6 time = 2020
* CHECK dout0_16 vdout0_16ck201 = 1.6 time = 2020
* CHECK dout0_17 vdout0_17ck201 = 1.6 time = 2020
* CHECK dout0_18 vdout0_18ck201 = 1.6 time = 2020
* CHECK dout0_19 vdout0_19ck201 = 0 time = 2020
* CHECK dout0_20 vdout0_20ck201 = 0 time = 2020
* CHECK dout0_21 vdout0_21ck201 = 1.6 time = 2020
* CHECK dout0_22 vdout0_22ck201 = 0 time = 2020
* CHECK dout0_23 vdout0_23ck201 = 0 time = 2020
* CHECK dout0_24 vdout0_24ck201 = 1.6 time = 2020
* CHECK dout0_25 vdout0_25ck201 = 0 time = 2020
* CHECK dout0_26 vdout0_26ck201 = 0 time = 2020
* CHECK dout0_27 vdout0_27ck201 = 1.6 time = 2020
* CHECK dout0_28 vdout0_28ck201 = 1.6 time = 2020
* CHECK dout0_29 vdout0_29ck201 = 0 time = 2020
* CHECK dout0_30 vdout0_30ck201 = 1.6 time = 2020
* CHECK dout0_31 vdout0_31ck201 = 1.6 time = 2020
* CHECK dout0_32 vdout0_32ck201 = 0 time = 2020
* CHECK dout0_0 vdout0_0ck202 = 0 time = 2030
* CHECK dout0_1 vdout0_1ck202 = 0 time = 2030
* CHECK dout0_2 vdout0_2ck202 = 1.6 time = 2030
* CHECK dout0_3 vdout0_3ck202 = 1.6 time = 2030
* CHECK dout0_4 vdout0_4ck202 = 0 time = 2030
* CHECK dout0_5 vdout0_5ck202 = 0 time = 2030
* CHECK dout0_6 vdout0_6ck202 = 0 time = 2030
* CHECK dout0_7 vdout0_7ck202 = 0 time = 2030
* CHECK dout0_8 vdout0_8ck202 = 1.6 time = 2030
* CHECK dout0_9 vdout0_9ck202 = 1.6 time = 2030
* CHECK dout0_10 vdout0_10ck202 = 1.6 time = 2030
* CHECK dout0_11 vdout0_11ck202 = 1.6 time = 2030
* CHECK dout0_12 vdout0_12ck202 = 1.6 time = 2030
* CHECK dout0_13 vdout0_13ck202 = 1.6 time = 2030
* CHECK dout0_14 vdout0_14ck202 = 1.6 time = 2030
* CHECK dout0_15 vdout0_15ck202 = 1.6 time = 2030
* CHECK dout0_16 vdout0_16ck202 = 1.6 time = 2030
* CHECK dout0_17 vdout0_17ck202 = 1.6 time = 2030
* CHECK dout0_18 vdout0_18ck202 = 0 time = 2030
* CHECK dout0_19 vdout0_19ck202 = 1.6 time = 2030
* CHECK dout0_20 vdout0_20ck202 = 1.6 time = 2030
* CHECK dout0_21 vdout0_21ck202 = 0 time = 2030
* CHECK dout0_22 vdout0_22ck202 = 1.6 time = 2030
* CHECK dout0_23 vdout0_23ck202 = 0 time = 2030
* CHECK dout0_24 vdout0_24ck202 = 0 time = 2030
* CHECK dout0_25 vdout0_25ck202 = 0 time = 2030
* CHECK dout0_26 vdout0_26ck202 = 1.6 time = 2030
* CHECK dout0_27 vdout0_27ck202 = 0 time = 2030
* CHECK dout0_28 vdout0_28ck202 = 0 time = 2030
* CHECK dout0_29 vdout0_29ck202 = 0 time = 2030
* CHECK dout0_30 vdout0_30ck202 = 1.6 time = 2030
* CHECK dout0_31 vdout0_31ck202 = 1.6 time = 2030
* CHECK dout0_32 vdout0_32ck202 = 0 time = 2030
* CHECK dout0_0 vdout0_0ck203 = 0 time = 2040
* CHECK dout0_1 vdout0_1ck203 = 1.6 time = 2040
* CHECK dout0_2 vdout0_2ck203 = 0 time = 2040
* CHECK dout0_3 vdout0_3ck203 = 1.6 time = 2040
* CHECK dout0_4 vdout0_4ck203 = 0 time = 2040
* CHECK dout0_5 vdout0_5ck203 = 0 time = 2040
* CHECK dout0_6 vdout0_6ck203 = 0 time = 2040
* CHECK dout0_7 vdout0_7ck203 = 0 time = 2040
* CHECK dout0_8 vdout0_8ck203 = 1.6 time = 2040
* CHECK dout0_9 vdout0_9ck203 = 0 time = 2040
* CHECK dout0_10 vdout0_10ck203 = 0 time = 2040
* CHECK dout0_11 vdout0_11ck203 = 0 time = 2040
* CHECK dout0_12 vdout0_12ck203 = 0 time = 2040
* CHECK dout0_13 vdout0_13ck203 = 0 time = 2040
* CHECK dout0_14 vdout0_14ck203 = 1.6 time = 2040
* CHECK dout0_15 vdout0_15ck203 = 0 time = 2040
* CHECK dout0_16 vdout0_16ck203 = 1.6 time = 2040
* CHECK dout0_17 vdout0_17ck203 = 0 time = 2040
* CHECK dout0_18 vdout0_18ck203 = 1.6 time = 2040
* CHECK dout0_19 vdout0_19ck203 = 1.6 time = 2040
* CHECK dout0_20 vdout0_20ck203 = 0 time = 2040
* CHECK dout0_21 vdout0_21ck203 = 0 time = 2040
* CHECK dout0_22 vdout0_22ck203 = 0 time = 2040
* CHECK dout0_23 vdout0_23ck203 = 0 time = 2040
* CHECK dout0_24 vdout0_24ck203 = 0 time = 2040
* CHECK dout0_25 vdout0_25ck203 = 1.6 time = 2040
* CHECK dout0_26 vdout0_26ck203 = 0 time = 2040
* CHECK dout0_27 vdout0_27ck203 = 1.6 time = 2040
* CHECK dout0_28 vdout0_28ck203 = 1.6 time = 2040
* CHECK dout0_29 vdout0_29ck203 = 0 time = 2040
* CHECK dout0_30 vdout0_30ck203 = 0 time = 2040
* CHECK dout0_31 vdout0_31ck203 = 1.6 time = 2040
* CHECK dout0_32 vdout0_32ck203 = 0 time = 2040
* CHECK dout1_0 vdout1_0ck204 = 0 time = 2050
* CHECK dout1_1 vdout1_1ck204 = 0 time = 2050
* CHECK dout1_2 vdout1_2ck204 = 0 time = 2050
* CHECK dout1_3 vdout1_3ck204 = 1.6 time = 2050
* CHECK dout1_4 vdout1_4ck204 = 0 time = 2050
* CHECK dout1_5 vdout1_5ck204 = 1.6 time = 2050
* CHECK dout1_6 vdout1_6ck204 = 1.6 time = 2050
* CHECK dout1_7 vdout1_7ck204 = 1.6 time = 2050
* CHECK dout1_8 vdout1_8ck204 = 1.6 time = 2050
* CHECK dout1_9 vdout1_9ck204 = 0 time = 2050
* CHECK dout1_10 vdout1_10ck204 = 0 time = 2050
* CHECK dout1_11 vdout1_11ck204 = 1.6 time = 2050
* CHECK dout1_12 vdout1_12ck204 = 0 time = 2050
* CHECK dout1_13 vdout1_13ck204 = 0 time = 2050
* CHECK dout1_14 vdout1_14ck204 = 1.6 time = 2050
* CHECK dout1_15 vdout1_15ck204 = 1.6 time = 2050
* CHECK dout1_16 vdout1_16ck204 = 1.6 time = 2050
* CHECK dout1_17 vdout1_17ck204 = 1.6 time = 2050
* CHECK dout1_18 vdout1_18ck204 = 1.6 time = 2050
* CHECK dout1_19 vdout1_19ck204 = 0 time = 2050
* CHECK dout1_20 vdout1_20ck204 = 0 time = 2050
* CHECK dout1_21 vdout1_21ck204 = 1.6 time = 2050
* CHECK dout1_22 vdout1_22ck204 = 0 time = 2050
* CHECK dout1_23 vdout1_23ck204 = 0 time = 2050
* CHECK dout1_24 vdout1_24ck204 = 1.6 time = 2050
* CHECK dout1_25 vdout1_25ck204 = 0 time = 2050
* CHECK dout1_26 vdout1_26ck204 = 0 time = 2050
* CHECK dout1_27 vdout1_27ck204 = 1.6 time = 2050
* CHECK dout1_28 vdout1_28ck204 = 1.6 time = 2050
* CHECK dout1_29 vdout1_29ck204 = 0 time = 2050
* CHECK dout1_30 vdout1_30ck204 = 1.6 time = 2050
* CHECK dout1_31 vdout1_31ck204 = 1.6 time = 2050
* CHECK dout1_32 vdout1_32ck204 = 0 time = 2050
.include /home/bala/git_stuff/internship/syn/sram/sram_128x32/out_final/functional_meas.sp
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
